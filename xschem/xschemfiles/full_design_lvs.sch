v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N -8570 16420 -8570 16460 {
lab=Vbias}
N -8630 16490 -8610 16490 {
lab=Vbias}
N -8630 16440 -8630 16490 {
lab=Vbias}
N -8630 16440 -8570 16440 {
lab=Vbias}
N -8570 16520 -8570 16560 {
lab=gnd}
N -8570 16490 -8570 16530 {
lab=gnd}
N -8970 16300 -8970 16320 {
lab=Vdd}
N -8790 16300 -8790 16320 {
lab=Vdd}
N -8930 16350 -8830 16350 {
lab=Vbp}
N -8970 16300 -8790 16300 {
lab=Vdd}
N -9010 16280 -9010 16300 {
lab=Vdd}
N -9010 16300 -8950 16300 {
lab=Vdd}
N -8800 16280 -8800 16300 {
lab=Vdd}
N -8970 16250 -8970 16300 {
lab=Vdd}
N -8840 16250 -8840 16300 {
lab=Vdd}
N -9010 16220 -8930 16220 {
lab=Vdd}
N -8930 16220 -8930 16300 {
lab=Vdd}
N -8880 16220 -8800 16220 {
lab=Vdd}
N -8880 16220 -8880 16300 {
lab=Vdd}
N -8970 16310 -8970 16350 {
lab=Vdd}
N -8790 16300 -8790 16350 {
lab=Vdd}
N -9010 16250 -9010 16300 {
lab=Vdd}
N -8800 16250 -8800 16290 {
lab=Vdd}
N -8970 16380 -8970 16410 {
lab=vin1}
N -8790 16380 -8790 16410 {
lab=vin2}
N -8900 16450 -8900 16490 {
lab=Vs}
N -8960 16520 -8940 16520 {
lab=Vbias}
N -8960 16470 -8960 16520 {
lab=Vbias}
N -8900 16550 -8900 16590 {
lab=gnd}
N -8900 16520 -8900 16560 {
lab=gnd}
N -8900 16290 -8880 16290 {
lab=Vdd}
N -8750 15780 -8750 15860 {
lab=#net1}
N -8570 15780 -8570 15860 {
lab=Vbp}
N -8750 15700 -8750 15720 {
lab=Vdd}
N -8570 15700 -8570 15720 {
lab=Vdd}
N -8750 15920 -8750 15940 {
lab=#net2}
N -8750 15940 -8570 15940 {
lab=#net2}
N -8570 15920 -8570 15940 {
lab=#net2}
N -8710 15750 -8610 15750 {
lab=#net1}
N -8670 15750 -8670 15820 {
lab=#net1}
N -8750 15820 -8670 15820 {
lab=#net1}
N -9150 15680 -9150 15710 {
lab=Vdd}
N -9150 15680 -8960 15680 {
lab=Vdd}
N -8960 15680 -8960 15710 {
lab=Vdd}
N -9150 15770 -9150 15850 {
lab=Vcm_det1}
N -8960 15770 -8960 15850 {
lab=Vcm_det1}
N -9210 15740 -9190 15740 {
lab=vin1}
N -9210 15740 -9210 15880 {
lab=vin1}
N -9210 15880 -9190 15880 {
lab=vin1}
N -8920 15740 -8900 15740 {
lab=vin2}
N -8900 15740 -8900 15880 {
lab=vin2}
N -8920 15880 -8900 15880 {
lab=vin2}
N -8350 15710 -8350 15740 {
lab=Vdd}
N -8350 15710 -8160 15710 {
lab=Vdd}
N -8160 15710 -8160 15740 {
lab=Vdd}
N -8350 15800 -8350 15880 {
lab=Vcm1}
N -8160 15800 -8160 15880 {
lab=Vcm1}
N -8350 15940 -8350 15970 {
lab=gnd}
N -8160 15940 -8160 15970 {
lab=gnd}
N -8410 15770 -8390 15770 {
lab=Vc1+}
N -8410 15770 -8410 15910 {
lab=Vc1+}
N -8410 15910 -8390 15910 {
lab=Vc1+}
N -8120 15770 -8100 15770 {
lab=Vc1+}
N -8100 15770 -8100 15910 {
lab=Vc1+}
N -8120 15910 -8100 15910 {
lab=Vc1+}
N -8660 15940 -8660 15970 {
lab=#net2}
N -8660 16030 -8660 16060 {
lab=gnd}
N -9150 15810 -8960 15810 {
lab=Vcm_det1}
N -8350 15840 -8160 15840 {
lab=Vcm1}
N -8820 15890 -8790 15890 {
lab=Vcm_det1}
N -8530 15890 -8500 15890 {
lab=Vcm1}
N -8750 15700 -8570 15700 {
lab=Vdd}
N -8350 15970 -8160 15970 {
lab=gnd}
N -8820 16040 -8820 16060 {
lab=gnd}
N -8820 16060 -8520 16060 {
lab=gnd}
N -8520 16030 -8520 16060 {
lab=gnd}
N -8860 16010 -8860 16060 {
lab=gnd}
N -8860 16060 -8820 16060 {
lab=gnd}
N -8820 15980 -8780 15980 {
lab=gnd}
N -8780 15980 -8780 16060 {
lab=gnd}
N -8480 16000 -8480 16060 {
lab=gnd}
N -8520 16060 -8480 16060 {
lab=gnd}
N -8570 15970 -8520 15970 {
lab=gnd}
N -8570 15970 -8570 16060 {
lab=gnd}
N -8790 15680 -8790 15700 {
lab=Vdd}
N -8790 15700 -8730 15700 {
lab=Vdd}
N -8580 15680 -8580 15700 {
lab=Vdd}
N -8750 15650 -8750 15700 {
lab=Vdd}
N -8620 15650 -8620 15700 {
lab=Vdd}
N -8790 15620 -8710 15620 {
lab=Vdd}
N -8710 15620 -8710 15700 {
lab=Vdd}
N -8660 15620 -8580 15620 {
lab=Vdd}
N -8660 15620 -8660 15700 {
lab=Vdd}
N -9150 15910 -9150 15940 {
lab=gnd}
N -9150 15940 -8960 15940 {
lab=gnd}
N -8960 15910 -8960 15940 {
lab=gnd}
N -8750 15710 -8750 15750 {
lab=Vdd}
N -8570 15700 -8570 15750 {
lab=Vdd}
N -8790 15650 -8790 15700 {
lab=Vdd}
N -8580 15650 -8580 15690 {
lab=Vdd}
N -8820 16010 -8820 16050 {
lab=gnd}
N -8520 16000 -8520 16040 {
lab=gnd}
N -8660 16000 -8660 16040 {
lab=gnd}
N -9150 15740 -9100 15740 {
lab=gnd}
N -9030 15740 -8960 15740 {
lab=gnd}
N -9100 15740 -9030 15740 {
lab=gnd}
N -9150 15880 -8960 15880 {
lab=Vdd}
N -8350 15770 -8160 15770 {
lab=gnd}
N -8350 15910 -8160 15910 {
lab=Vdd}
N -8750 15890 -8570 15890 {
lab=gnd}
N -8730 16000 -8700 16000 {
lab=Vbias}
N -7950 16450 -7950 16470 {
lab=#net3}
N -7950 16470 -7770 16470 {
lab=#net3}
N -7620 16450 -7620 16470 {
lab=#net3}
N -7950 16180 -7950 16200 {
lab=Vdd}
N -7950 16180 -7770 16180 {
lab=Vdd}
N -7620 16180 -7620 16200 {
lab=Vdd}
N -7770 16180 -7620 16180 {
lab=Vdd}
N -7770 16470 -7620 16470 {
lab=#net3}
N -7950 16330 -7820 16330 {
lab=vo1}
N -7760 16330 -7620 16330 {
lab=vo2}
N -8110 16230 -7990 16230 {
lab=Vbn}
N -7580 16230 -7470 16230 {
lab=Vbn}
N -8020 16420 -7990 16420 {
lab=vin1}
N -7580 16420 -7540 16420 {
lab=vin2}
N -7950 16320 -7950 16390 {
lab=vo1}
N -7620 16320 -7620 16390 {
lab=vo2}
N -7620 16250 -7620 16320 {
lab=vo2}
N -7950 16260 -7950 16320 {
lab=vo1}
N -7790 16470 -7790 16530 {
lab=#net3}
N -8110 16430 -8110 16470 {
lab=gnd}
N -7440 16430 -7440 16470 {
lab=gnd}
N -8150 16400 -8150 16470 {
lab=gnd}
N -8150 16470 -8110 16470 {
lab=gnd}
N -8110 16370 -8090 16370 {
lab=gnd}
N -8090 16370 -8090 16470 {
lab=gnd}
N -8110 16400 -8110 16450 {
lab=gnd}
N -7460 16370 -7440 16370 {
lab=gnd}
N -7460 16370 -7460 16470 {
lab=gnd}
N -7440 16400 -7440 16450 {
lab=gnd}
N -7400 16400 -7400 16470 {
lab=gnd}
N -7440 16470 -7400 16470 {
lab=gnd}
N -7960 16160 -7960 16180 {
lab=Vdd}
N -7960 16180 -7950 16180 {
lab=Vdd}
N -7630 16160 -7630 16180 {
lab=Vdd}
N -7960 16100 -7890 16100 {
lab=Vdd}
N -7890 16100 -7890 16180 {
lab=Vdd}
N -7660 16100 -7630 16100 {
lab=Vdd}
N -7660 16100 -7660 16180 {
lab=Vdd}
N -7960 16130 -7940 16130 {
lab=Vdd}
N -7940 16130 -7940 16180 {
lab=Vdd}
N -7650 16130 -7630 16130 {
lab=Vdd}
N -7650 16130 -7650 16180 {
lab=Vdd}
N -7590 16130 -7590 16180 {
lab=Vdd}
N -7620 16180 -7590 16180 {
lab=Vdd}
N -8000 16130 -8000 16180 {
lab=Vdd}
N -8000 16180 -7960 16180 {
lab=Vdd}
N -7950 16190 -7950 16230 {
lab=Vdd}
N -7620 16190 -7620 16230 {
lab=Vdd}
N -7890 16830 -7890 16910 {
lab=#net4}
N -7710 16830 -7710 16910 {
lab=Vbn}
N -7890 16750 -7890 16770 {
lab=Vdd}
N -7710 16750 -7710 16770 {
lab=Vdd}
N -7890 16970 -7890 16990 {
lab=#net5}
N -7890 16990 -7710 16990 {
lab=#net5}
N -7710 16970 -7710 16990 {
lab=#net5}
N -7850 16800 -7750 16800 {
lab=#net4}
N -7810 16800 -7810 16870 {
lab=#net4}
N -7890 16870 -7810 16870 {
lab=#net4}
N -8290 16730 -8290 16760 {
lab=Vdd}
N -8290 16730 -8100 16730 {
lab=Vdd}
N -8100 16730 -8100 16760 {
lab=Vdd}
N -8290 16820 -8290 16900 {
lab=Vcm_det}
N -8100 16820 -8100 16900 {
lab=Vcm_det}
N -8350 16790 -8330 16790 {
lab=vo1}
N -8350 16790 -8350 16930 {
lab=vo1}
N -8350 16930 -8330 16930 {
lab=vo1}
N -8060 16790 -8040 16790 {
lab=vo2}
N -8040 16790 -8040 16930 {
lab=vo2}
N -8060 16930 -8040 16930 {
lab=vo2}
N -7490 16760 -7490 16790 {
lab=Vdd}
N -7490 16760 -7300 16760 {
lab=Vdd}
N -7300 16760 -7300 16790 {
lab=Vdd}
N -7490 16850 -7490 16930 {
lab=Vcm}
N -7300 16850 -7300 16930 {
lab=Vcm}
N -7490 16990 -7490 17020 {
lab=gnd}
N -7300 16990 -7300 17020 {
lab=gnd}
N -7550 16820 -7530 16820 {
lab=Vc1+}
N -7550 16820 -7550 16960 {
lab=Vc1+}
N -7550 16960 -7530 16960 {
lab=Vc1+}
N -7260 16820 -7240 16820 {
lab=Vc1+}
N -7240 16820 -7240 16960 {
lab=Vc1+}
N -7260 16960 -7240 16960 {
lab=Vc1+}
N -7800 16990 -7800 17020 {
lab=#net5}
N -7800 17080 -7800 17110 {
lab=gnd}
N -8290 16860 -8100 16860 {
lab=Vcm_det}
N -7490 16890 -7300 16890 {
lab=Vcm}
N -7960 16940 -7930 16940 {
lab=Vcm_det}
N -7670 16940 -7640 16940 {
lab=Vcm}
N -7890 16750 -7710 16750 {
lab=Vdd}
N -7490 17020 -7300 17020 {
lab=gnd}
N -7960 17090 -7960 17110 {
lab=gnd}
N -7960 17110 -7660 17110 {
lab=gnd}
N -7660 17080 -7660 17110 {
lab=gnd}
N -8000 17060 -8000 17110 {
lab=gnd}
N -8000 17110 -7960 17110 {
lab=gnd}
N -7960 17030 -7920 17030 {
lab=gnd}
N -7920 17030 -7920 17110 {
lab=gnd}
N -7620 17050 -7620 17110 {
lab=gnd}
N -7660 17110 -7620 17110 {
lab=gnd}
N -7710 17020 -7660 17020 {
lab=gnd}
N -7710 17020 -7710 17110 {
lab=gnd}
N -7930 16730 -7930 16750 {
lab=Vdd}
N -7930 16750 -7870 16750 {
lab=Vdd}
N -7720 16730 -7720 16750 {
lab=Vdd}
N -7890 16700 -7890 16750 {
lab=Vdd}
N -7760 16700 -7760 16750 {
lab=Vdd}
N -7930 16670 -7850 16670 {
lab=Vdd}
N -7850 16670 -7850 16750 {
lab=Vdd}
N -7800 16670 -7720 16670 {
lab=Vdd}
N -7800 16670 -7800 16750 {
lab=Vdd}
N -8290 16960 -8290 16990 {
lab=gnd}
N -8290 16990 -8100 16990 {
lab=gnd}
N -8100 16960 -8100 16990 {
lab=gnd}
N -7890 16760 -7890 16800 {
lab=Vdd}
N -7710 16750 -7710 16800 {
lab=Vdd}
N -7930 16700 -7930 16750 {
lab=Vdd}
N -7720 16700 -7720 16740 {
lab=Vdd}
N -7960 17060 -7960 17100 {
lab=gnd}
N -7660 17050 -7660 17090 {
lab=gnd}
N -7800 17050 -7800 17090 {
lab=gnd}
N -8290 16790 -8240 16790 {
lab=gnd}
N -8170 16790 -8100 16790 {
lab=gnd}
N -8240 16790 -8170 16790 {
lab=gnd}
N -8290 16930 -8100 16930 {
lab=Vdd}
N -7490 16820 -7300 16820 {
lab=gnd}
N -7490 16960 -7300 16960 {
lab=Vdd}
N -7890 16940 -7710 16940 {
lab=gnd}
N -7870 17050 -7840 17050 {
lab=Vbias1}
N -7950 16420 -7620 16420 {
lab=gnd}
N -7790 16590 -7670 16590 {
lab=gnd}
N -7790 16560 -7760 16560 {
lab=gnd}
N -7760 16560 -7760 16590 {
lab=gnd}
N -7890 16560 -7830 16560 {
lab=Vbias1}
N -8110 16470 -8090 16470 {
lab=gnd}
N -7460 16470 -7440 16470 {
lab=gnd}
N -8880 16750 -8850 16750 {
lab=gnd}
N -8850 16750 -8850 16810 {
lab=gnd}
N -8880 16810 -8850 16810 {
lab=gnd}
N -8880 16780 -8850 16780 {
lab=gnd}
N -8950 16810 -8500 16810 {
lab=gnd}
N -8920 16750 -8920 16780 {
lab=Vdd}
N -8760 16750 -8760 16780 {
lab=Vdd}
N -8920 16720 -8920 16750 {
lab=Vdd}
N -8920 16720 -8500 16720 {
lab=Vdd}
N -8760 16720 -8760 16750 {
lab=Vdd}
N -8720 16750 -8680 16750 {
lab=gnd}
N -8680 16750 -8680 16810 {
lab=gnd}
N -8720 16780 -8680 16780 {
lab=gnd}
N -8610 16720 -8610 16780 {
lab=Vdd}
N -8570 16780 -8530 16780 {
lab=gnd}
N -8530 16780 -8530 16810 {
lab=gnd}
N -8570 16750 -8530 16750 {
lab=gnd}
N -8530 16750 -8530 16780 {
lab=gnd}
N -8500 16720 -8380 16720 {
lab=Vdd}
N -8500 16810 -8390 16810 {
lab=gnd}
N -8470 16720 -8470 16780 {
lab=Vdd}
N -8430 16750 -8400 16750 {
lab=gnd}
N -8400 16750 -8400 16810 {
lab=gnd}
N -8430 16780 -8400 16780 {
lab=gnd}
N -9000 16940 -8970 16940 {
lab=Vdd}
N -8970 16940 -8970 17000 {
lab=Vdd}
N -9000 17000 -8970 17000 {
lab=Vdd}
N -9000 16970 -8970 16970 {
lab=Vdd}
N -9070 17000 -8620 17000 {
lab=Vdd}
N -9040 16940 -9040 16970 {
lab=gnd}
N -8880 16940 -8880 16970 {
lab=gnd}
N -9040 16910 -9040 16940 {
lab=gnd}
N -9040 16910 -8620 16910 {
lab=gnd}
N -8880 16910 -8880 16940 {
lab=gnd}
N -8840 16940 -8800 16940 {
lab=Vdd}
N -8800 16940 -8800 17000 {
lab=Vdd}
N -8840 16970 -8800 16970 {
lab=Vdd}
N -8730 16910 -8730 16970 {
lab=gnd}
N -8690 16970 -8650 16970 {
lab=Vdd}
N -8650 16970 -8650 17000 {
lab=Vdd}
N -8690 16940 -8650 16940 {
lab=Vdd}
N -8650 16940 -8650 16970 {
lab=Vdd}
N -8620 16910 -8500 16910 {
lab=gnd}
N -8620 17000 -8510 17000 {
lab=Vdd}
N -8590 16910 -8590 16970 {
lab=gnd}
N -8550 16940 -8520 16940 {
lab=Vdd}
N -8520 16940 -8520 17000 {
lab=Vdd}
N -8550 16970 -8520 16970 {
lab=Vdd}
N -8500 16910 -8400 16910 {
lab=gnd}
N -8510 17000 -8360 17000 {
lab=Vdd}
N -8410 16940 -8380 16940 {
lab=Vdd}
N -8380 16940 -8380 17000 {
lab=Vdd}
N -8410 16970 -8380 16970 {
lab=Vdd}
N -8450 16910 -8450 16970 {
lab=gnd}
N -9170 16910 -9040 16910 {
lab=gnd}
N -9180 17000 -9070 17000 {
lab=Vdd}
N -9170 16910 -9170 16970 {
lab=gnd}
N -9130 16940 -9100 16940 {
lab=Vdd}
N -9100 16940 -9100 17000 {
lab=Vdd}
N -9130 16970 -9100 16970 {
lab=Vdd}
N -8850 17130 -8820 17130 {
lab=gnd}
N -8820 17130 -8820 17190 {
lab=gnd}
N -8850 17190 -8820 17190 {
lab=gnd}
N -8850 17160 -8820 17160 {
lab=gnd}
N -8890 17130 -8890 17160 {
lab=Vbias1}
N -8890 17100 -8890 17130 {
lab=Vbias1}
N -8890 17100 -8810 17100 {
lab=Vbias1}
N -8540 17160 -8510 17160 {
lab=Vbias1}
N -8540 17220 -8510 17220 {
lab=gnd}
N -8580 17160 -8580 17190 {
lab=Vbias1}
N -8580 17130 -8580 17160 {
lab=Vbias1}
N -8580 17130 -8500 17130 {
lab=Vbias1}
N -8540 17190 -8520 17190 {
lab=gnd}
N -8520 17190 -8520 17220 {
lab=gnd}
N -8510 17130 -8510 17160 {
lab=Vbias1}
N -8500 17130 -8460 17130 {
lab=Vbias1}
N -6270 15670 -6270 15790 {
lab=Vo+}
N -6100 15670 -6100 15780 {
lab=Vo-}
N -6100 15780 -6100 15790 {
lab=Vo-}
N -6270 15590 -6270 15610 {
lab=Vdd}
N -6270 15590 -6100 15590 {
lab=Vdd}
N -6100 15590 -6100 15610 {
lab=Vdd}
N -6230 15640 -6220 15640 {
lab=Vo-}
N -6220 15640 -6220 15820 {
lab=Vo-}
N -6230 15820 -6220 15820 {
lab=Vo-}
N -6150 15640 -6140 15640 {
lab=Vo+}
N -6150 15640 -6150 15820 {
lab=Vo+}
N -6150 15820 -6140 15820 {
lab=Vo+}
N -6420 15590 -6270 15590 {
lab=Vdd}
N -6420 15590 -6420 15610 {
lab=Vdd}
N -6100 15590 -5940 15590 {
lab=Vdd}
N -5940 15590 -5940 15610 {
lab=Vdd}
N -6420 15670 -6420 15690 {
lab=Vo+}
N -6420 15690 -6270 15690 {
lab=Vo+}
N -5940 15670 -5940 15690 {
lab=Vo-}
N -6100 15690 -5940 15690 {
lab=Vo-}
N -6270 15680 -6150 15680 {
lab=Vo+}
N -6220 15700 -6100 15700 {
lab=Vo-}
N -6270 15850 -6270 15920 {
lab=#net6}
N -6100 15850 -6100 15920 {
lab=#net7}
N -6270 15980 -6270 16020 {
lab=#net8}
N -6270 16020 -6100 16020 {
lab=#net8}
N -6100 15970 -6100 16020 {
lab=#net8}
N -5940 15980 -5940 16020 {
lab=#net8}
N -6100 16020 -5940 16020 {
lab=#net8}
N -5940 15900 -5940 15920 {
lab=#net7}
N -6100 15900 -5940 15900 {
lab=#net7}
N -6400 15980 -6400 16020 {
lab=#net8}
N -6400 16020 -6270 16020 {
lab=#net8}
N -6400 15890 -6400 15920 {
lab=#net6}
N -6400 15890 -6270 15890 {
lab=#net6}
N -6160 16020 -6160 16050 {
lab=#net8}
N -6250 16080 -6200 16080 {
lab=clk}
N -6160 16110 -6160 16150 {
lab=GND}
N -6270 15880 -6230 15880 {
lab=#net6}
N -6170 15880 -6100 15880 {
lab=#net7}
N -6480 15950 -6440 15950 {
lab=Vc-}
N -6340 15950 -6310 15950 {
lab=vo1}
N -6060 15950 -6030 15950 {
lab=vo2}
N -5900 15950 -5870 15950 {
lab=Vc+}
N -5900 15640 -5860 15640 {
lab=clk}
N -6500 15640 -6460 15640 {
lab=clk}
N -6270 15950 -6100 15950 {
lab=GND}
N -5970 15950 -5940 15950 {
lab=GND}
N -6400 15950 -6370 15950 {
lab=GND}
N -6420 15620 -6420 15640 {
lab=Vdd}
N -6270 15620 -6270 15640 {
lab=Vdd}
N -6100 15610 -6100 15630 {
lab=Vdd}
N -6100 15620 -6100 15640 {
lab=Vdd}
N -5940 15600 -5940 15640 {
lab=Vdd}
N -6270 15600 -6270 15640 {
lab=Vdd}
N -6420 15590 -6420 15640 {
lab=Vdd}
N -6100 15820 -6020 15820 {
lab=GND}
N -6350 15820 -6270 15820 {
lab=GND}
N -6200 15810 -6200 15880 {
lab=Vdd}
N -6200 15920 -6150 15920 {
lab=clk}
N -6160 16080 -6130 16080 {
lab=GND}
N -6130 16080 -6130 16130 {
lab=GND}
N -6160 16130 -6130 16130 {
lab=GND}
N -5460 15600 -5460 15620 {
lab=Vdd}
N -5460 15600 -5290 15600 {
lab=Vdd}
N -5290 15600 -5290 15620 {
lab=Vdd}
N -5420 15650 -5410 15650 {
lab=Vo1+}
N -5340 15650 -5330 15650 {
lab=Vo1-}
N -5610 15600 -5460 15600 {
lab=Vdd}
N -5610 15600 -5610 15620 {
lab=Vdd}
N -5290 15600 -5130 15600 {
lab=Vdd}
N -5130 15600 -5130 15620 {
lab=Vdd}
N -5610 15680 -5610 15700 {
lab=Q}
N -5130 15680 -5130 15700 {
lab=Q1}
N -5090 15650 -5050 15650 {
lab=Vo+}
N -5690 15650 -5650 15650 {
lab=Vo-}
N -5610 15630 -5610 15650 {
lab=Vdd}
N -5460 15630 -5460 15650 {
lab=Vdd}
N -5290 15620 -5290 15640 {
lab=Vdd}
N -5290 15630 -5290 15650 {
lab=Vdd}
N -5130 15610 -5130 15650 {
lab=Vdd}
N -5460 15610 -5460 15650 {
lab=Vdd}
N -5610 15600 -5610 15650 {
lab=Vdd}
N -5290 15680 -5290 15770 {
lab=#net9}
N -5460 15850 -5460 15970 {
lab=Q}
N -5290 15850 -5290 15960 {
lab=Q1}
N -5290 15960 -5290 15970 {
lab=Q1}
N -5460 15770 -5460 15790 {
lab=#net10}
N -5290 15770 -5290 15790 {
lab=#net9}
N -5420 15820 -5410 15820 {
lab=Q1}
N -5410 15820 -5410 16000 {
lab=Q1}
N -5420 16000 -5410 16000 {
lab=Q1}
N -5340 15820 -5330 15820 {
lab=Q}
N -5340 15820 -5340 16000 {
lab=Q}
N -5340 16000 -5330 16000 {
lab=Q}
N -5460 15860 -5340 15860 {
lab=Q}
N -5410 15880 -5290 15880 {
lab=Q1}
N -5290 16000 -5210 16000 {
lab=GND}
N -5460 15680 -5460 15770 {
lab=#net10}
N -5460 16140 -5460 16180 {
lab=GND}
N -5460 16180 -5290 16180 {
lab=GND}
N -5290 16130 -5290 16180 {
lab=GND}
N -5130 16140 -5130 16180 {
lab=GND}
N -5290 16180 -5130 16180 {
lab=GND}
N -5130 16060 -5130 16080 {
lab=Q1}
N -5610 16140 -5610 16180 {
lab=GND}
N -5590 16180 -5460 16180 {
lab=GND}
N -5610 16050 -5610 16080 {
lab=Q}
N -5350 16180 -5350 16210 {
lab=GND}
N -5690 16110 -5650 16110 {
lab=Vo1+}
N -5530 16110 -5500 16110 {
lab=Vo-}
N -5250 16110 -5220 16110 {
lab=Vo+}
N -5090 16110 -5060 16110 {
lab=Vo1-}
N -5460 16110 -5290 16110 {
lab=GND}
N -5160 16110 -5130 16110 {
lab=GND}
N -5610 16110 -5580 16110 {
lab=GND}
N -5460 16030 -5460 16080 {
lab=#net11}
N -5290 16030 -5290 16080 {
lab=#net12}
N -5610 15700 -5610 16050 {
lab=Q}
N -5130 15700 -5130 16050 {
lab=Q1}
N -5130 16050 -5130 16060 {
lab=Q1}
N -5610 16180 -5590 16180 {
lab=GND}
N -5350 15650 -5340 15650 {
lab=Vo1-}
N -5410 15650 -5400 15650 {
lab=Vo1+}
N -5610 15890 -5460 15890 {
lab=Q}
N -5290 15900 -5130 15900 {
lab=Q1}
N -6140 16260 -6060 16260 {
lab=Vo+}
N -6120 16500 -6040 16500 {
lab=Vo-}
N -6000 16520 -5920 16520 {
lab=Vo1-}
N -5520 15820 -5460 15820 {
lab=Vdd}
N -5520 15600 -5520 15820 {
lab=Vdd}
N -5290 15820 -5250 15820 {
lab=Vdd}
N -5250 15600 -5250 15820 {
lab=Vdd}
N -5550 16000 -5460 16000 {
lab=GND}
N -5550 16000 -5550 16180 {
lab=GND}
N -6000 16350 -6000 16370 {
lab=GND}
N -6040 16240 -6040 16320 {
lab=Vo+}
N -6060 16260 -6040 16260 {
lab=Vo+}
N -6000 16270 -6000 16290 {
lab=Vo1+}
N -6000 16280 -5880 16280 {
lab=Vo1+}
N -6000 16180 -6000 16210 {
lab=Vdd}
N -6000 16190 -6000 16240 {
lab=Vdd}
N -6000 16320 -6000 16360 {
lab=GND}
N -6040 16480 -6040 16560 {
lab=Vo-}
N -6000 16510 -6000 16530 {
lab=Vo1-}
N -6000 16600 -6000 16610 {
lab=GND}
N -6000 16590 -6000 16600 {
lab=GND}
N -6000 16560 -6000 16600 {
lab=GND}
N -6000 16430 -6000 16450 {
lab=Vdd}
N -6000 16440 -6000 16480 {
lab=Vdd}
N -6250 16870 -6250 16990 {
lab=Vo2+}
N -6080 16870 -6080 16980 {
lab=Vo2-}
N -6080 16980 -6080 16990 {
lab=Vo2-}
N -6250 16790 -6250 16810 {
lab=Vdd}
N -6250 16790 -6080 16790 {
lab=Vdd}
N -6080 16790 -6080 16810 {
lab=Vdd}
N -6210 16840 -6200 16840 {
lab=Vo2-}
N -6200 16840 -6200 17020 {
lab=Vo2-}
N -6210 17020 -6200 17020 {
lab=Vo2-}
N -6130 16840 -6120 16840 {
lab=Vo2+}
N -6130 16840 -6130 17020 {
lab=Vo2+}
N -6130 17020 -6120 17020 {
lab=Vo2+}
N -6400 16790 -6250 16790 {
lab=Vdd}
N -6400 16790 -6400 16810 {
lab=Vdd}
N -6080 16790 -5920 16790 {
lab=Vdd}
N -5920 16790 -5920 16810 {
lab=Vdd}
N -6400 16870 -6400 16890 {
lab=Vo2+}
N -6400 16890 -6250 16890 {
lab=Vo2+}
N -5920 16870 -5920 16890 {
lab=Vo2-}
N -6080 16890 -5920 16890 {
lab=Vo2-}
N -6250 16880 -6130 16880 {
lab=Vo2+}
N -6200 16900 -6080 16900 {
lab=Vo2-}
N -6250 17050 -6250 17120 {
lab=#net13}
N -6080 17050 -6080 17120 {
lab=#net14}
N -6250 17180 -6250 17220 {
lab=#net15}
N -6250 17220 -6080 17220 {
lab=#net15}
N -6080 17170 -6080 17220 {
lab=#net15}
N -5920 17180 -5920 17220 {
lab=#net15}
N -6080 17220 -5920 17220 {
lab=#net15}
N -5920 17100 -5920 17120 {
lab=#net14}
N -6080 17100 -5920 17100 {
lab=#net14}
N -6380 17180 -6380 17220 {
lab=#net15}
N -6380 17220 -6250 17220 {
lab=#net15}
N -6380 17090 -6380 17120 {
lab=#net13}
N -6380 17090 -6250 17090 {
lab=#net13}
N -6140 17220 -6140 17250 {
lab=#net15}
N -6230 17280 -6180 17280 {
lab=clk}
N -6140 17310 -6140 17350 {
lab=GND}
N -6250 17080 -6210 17080 {
lab=#net13}
N -6150 17080 -6080 17080 {
lab=#net14}
N -6460 17150 -6420 17150 {
lab=Vc+}
N -6320 17150 -6290 17150 {
lab=vo1}
N -6040 17150 -6010 17150 {
lab=vo2}
N -5880 17150 -5850 17150 {
lab=Vc-}
N -5880 16840 -5840 16840 {
lab=clk}
N -6480 16840 -6440 16840 {
lab=clk}
N -6250 17150 -6080 17150 {
lab=GND}
N -5950 17150 -5920 17150 {
lab=GND}
N -6380 17150 -6350 17150 {
lab=GND}
N -6400 16820 -6400 16840 {
lab=Vdd}
N -6250 16820 -6250 16840 {
lab=Vdd}
N -6080 16810 -6080 16830 {
lab=Vdd}
N -6080 16820 -6080 16840 {
lab=Vdd}
N -5920 16800 -5920 16840 {
lab=Vdd}
N -6250 16800 -6250 16840 {
lab=Vdd}
N -6400 16790 -6400 16840 {
lab=Vdd}
N -6080 17020 -6000 17020 {
lab=GND}
N -6330 17020 -6250 17020 {
lab=GND}
N -6180 17010 -6180 17080 {
lab=Vdd}
N -6180 17120 -6130 17120 {
lab=clk}
N -6140 17280 -6110 17280 {
lab=GND}
N -6110 17280 -6110 17330 {
lab=GND}
N -6140 17330 -6110 17330 {
lab=GND}
N -5440 16800 -5440 16820 {
lab=Vdd}
N -5440 16800 -5270 16800 {
lab=Vdd}
N -5270 16800 -5270 16820 {
lab=Vdd}
N -5400 16850 -5390 16850 {
lab=Vo3+}
N -5320 16850 -5310 16850 {
lab=Vo3-}
N -5590 16800 -5440 16800 {
lab=Vdd}
N -5590 16800 -5590 16820 {
lab=Vdd}
N -5270 16800 -5110 16800 {
lab=Vdd}
N -5110 16800 -5110 16820 {
lab=Vdd}
N -5590 16880 -5590 16900 {
lab=Q3}
N -5110 16880 -5110 16900 {
lab=Q2}
N -5070 16850 -5030 16850 {
lab=Vo2+}
N -5670 16850 -5630 16850 {
lab=Vo2-}
N -5590 16830 -5590 16850 {
lab=Vdd}
N -5440 16830 -5440 16850 {
lab=Vdd}
N -5270 16820 -5270 16840 {
lab=Vdd}
N -5270 16830 -5270 16850 {
lab=Vdd}
N -5110 16810 -5110 16850 {
lab=Vdd}
N -5440 16810 -5440 16850 {
lab=Vdd}
N -5590 16800 -5590 16850 {
lab=Vdd}
N -5270 16880 -5270 16970 {
lab=#net16}
N -5440 17050 -5440 17170 {
lab=Q3}
N -5270 17050 -5270 17160 {
lab=Q2}
N -5270 17160 -5270 17170 {
lab=Q2}
N -5440 16970 -5440 16990 {
lab=#net17}
N -5270 16970 -5270 16990 {
lab=#net16}
N -5400 17020 -5390 17020 {
lab=Q2}
N -5390 17020 -5390 17200 {
lab=Q2}
N -5400 17200 -5390 17200 {
lab=Q2}
N -5320 17020 -5310 17020 {
lab=Q3}
N -5320 17020 -5320 17200 {
lab=Q3}
N -5320 17200 -5310 17200 {
lab=Q3}
N -5440 17060 -5320 17060 {
lab=Q3}
N -5390 17080 -5270 17080 {
lab=Q2}
N -5270 17200 -5190 17200 {
lab=GND}
N -5440 16880 -5440 16970 {
lab=#net17}
N -5440 17340 -5440 17380 {
lab=GND}
N -5440 17380 -5270 17380 {
lab=GND}
N -5270 17330 -5270 17380 {
lab=GND}
N -5110 17340 -5110 17380 {
lab=GND}
N -5270 17380 -5110 17380 {
lab=GND}
N -5110 17260 -5110 17280 {
lab=Q2}
N -5590 17340 -5590 17380 {
lab=GND}
N -5570 17380 -5440 17380 {
lab=GND}
N -5590 17250 -5590 17280 {
lab=Q3}
N -5330 17380 -5330 17410 {
lab=GND}
N -5670 17310 -5630 17310 {
lab=Vo3+}
N -5510 17310 -5480 17310 {
lab=Vo2-}
N -5230 17310 -5200 17310 {
lab=Vo2+}
N -5070 17310 -5040 17310 {
lab=Vo3-}
N -5440 17310 -5270 17310 {
lab=GND}
N -5140 17310 -5110 17310 {
lab=GND}
N -5590 17310 -5560 17310 {
lab=GND}
N -5440 17230 -5440 17280 {
lab=#net18}
N -5270 17230 -5270 17280 {
lab=#net19}
N -5590 16900 -5590 17250 {
lab=Q3}
N -5110 16900 -5110 17250 {
lab=Q2}
N -5110 17250 -5110 17260 {
lab=Q2}
N -5590 17380 -5570 17380 {
lab=GND}
N -5330 16850 -5320 16850 {
lab=Vo3-}
N -5390 16850 -5380 16850 {
lab=Vo3+}
N -5590 17090 -5440 17090 {
lab=Q3}
N -5270 17100 -5110 17100 {
lab=Q2}
N -6120 17460 -6040 17460 {
lab=Vo2+}
N -6100 17700 -6020 17700 {
lab=Vo2-}
N -5980 17720 -5900 17720 {
lab=Vo3-}
N -5500 17020 -5440 17020 {
lab=Vdd}
N -5500 16800 -5500 17020 {
lab=Vdd}
N -5270 17020 -5230 17020 {
lab=Vdd}
N -5230 16800 -5230 17020 {
lab=Vdd}
N -5530 17200 -5440 17200 {
lab=GND}
N -5530 17200 -5530 17380 {
lab=GND}
N -5980 17550 -5980 17570 {
lab=GND}
N -6020 17440 -6020 17520 {
lab=Vo2+}
N -6040 17460 -6020 17460 {
lab=Vo2+}
N -5980 17470 -5980 17490 {
lab=Vo3+}
N -5980 17480 -5860 17480 {
lab=Vo3+}
N -5980 17380 -5980 17410 {
lab=Vdd}
N -5980 17390 -5980 17440 {
lab=Vdd}
N -5980 17520 -5980 17560 {
lab=GND}
N -6020 17680 -6020 17760 {
lab=Vo2-}
N -5980 17710 -5980 17730 {
lab=Vo3-}
N -5980 17800 -5980 17810 {
lab=GND}
N -5980 17790 -5980 17800 {
lab=GND}
N -5980 17760 -5980 17800 {
lab=GND}
N -5980 17630 -5980 17650 {
lab=Vdd}
N -5980 17640 -5980 17680 {
lab=Vdd}
N -5340 15940 -4780 15940 {
lab=Q}
N -4780 15940 -4780 16340 {
lab=Q}
N -4780 16340 -4740 16340 {
lab=Q}
N -5320 17130 -4960 17130 {
lab=Q3}
N -4960 16370 -4960 17130 {
lab=Q3}
N -4960 16370 -4740 16380 {
lab=Q3}
N -4620 16360 -4480 16360 {
lab=#net20}
N -6780 16320 -6780 16360 {
lab=Vc-}
N -6780 16240 -6780 16260 {
lab=Vc+}
N -6780 16290 -6760 16290 {
lab=Vc+}
N -6780 16250 -6760 16250 {
lab=Vc+}
N -6780 16390 -6750 16390 {
lab=Vc-}
N -6780 16350 -6750 16350 {
lab=Vc-}
N -6840 16290 -6820 16290 {
lab=Vc-}
N -6840 16390 -6820 16390 {
lab=gnd}
N -6840 16290 -6840 16330 {
lab=Vc-}
N -6840 16330 -6780 16330 {
lab=Vc-}
N -6840 16390 -6840 16430 {
lab=gnd}
N -6840 16430 -6780 16430 {
lab=gnd}
N -6780 16210 -6780 16240 {
lab=Vc+}
N -6750 16390 -6670 16390 {
lab=Vc-}
N -6760 16290 -6670 16290 {
lab=Vc+}
N -6670 16250 -6670 16290 {
lab=Vc+}
N -6760 16250 -6670 16250 {
lab=Vc+}
N -6670 16350 -6670 16390 {
lab=Vc-}
N -6780 16120 -6780 16150 {
lab=vdd}
N -6840 16180 -6820 16180 {
lab=Vc+}
N -6840 16180 -6840 16230 {
lab=Vc+}
N -6840 16230 -6780 16230 {
lab=Vc+}
N -6780 16180 -6720 16180 {
lab=vdd}
N -6720 16140 -6720 16180 {
lab=vdd}
N -6780 16430 -6780 16450 {
lab=gnd}
N -6720 16110 -6720 16140 {
lab=vdd}
N -6780 16110 -6720 16110 {
lab=vdd}
N -6780 16110 -6780 16120 {
lab=vdd}
N -6780 16420 -6780 16430 {
lab=gnd}
N -6750 16350 -6670 16350 {
lab=Vc-}
N -6850 16990 -6810 16990 {
lab=Vdd}
N -6770 16930 -6770 16960 {
lab=GND}
N -6770 16930 -6720 16930 {
lab=GND}
N -6720 16930 -6720 17050 {
lab=GND}
N -6770 17050 -6720 17050 {
lab=GND}
N -6770 17020 -6770 17050 {
lab=GND}
N -6770 16990 -6720 16990 {
lab=GND}
N -4480 16170 -4480 16360 {
lab=#net20}
N -4480 16170 -4180 16170 {
lab=#net20}
N -4230 16200 -4180 16200 {
lab=reset}
N -4220 16220 -4180 16220 {
lab=scan_en}
N -4220 16240 -4180 16240 {
lab=scan_in}
N -4960 16560 -4230 16560 {
lab=Q3}
N -4230 16270 -4230 16560 {
lab=Q3}
N -4230 16270 -4180 16270 {
lab=Q3}
N -4030 16060 -4030 16080 {
lab=Vdd}
N -4030 16340 -4030 16360 {
lab=GND}
N -4230 16110 -4180 16110 {
lab=clk}
N -4240 16220 -4220 16220 {
lab=scan_en}
N -4240 16200 -4230 16200 {
lab=reset}
N -3450 15490 -3410 15490 {
lab=#net21}
N -3660 15350 -3660 15370 {
lab=#net22}
N -2750 15520 -2710 15520 {
lab=#net23}
N -2960 15380 -2960 15400 {
lab=#net24}
N -2060 15520 -2020 15520 {
lab=#net25}
N -2270 15380 -2270 15400 {
lab=#net22}
N -1410 15520 -1370 15520 {
lab=o1}
N -1620 15380 -1620 15400 {
lab=#net26}
N -650 15510 -610 15510 {
lab=o2}
N -860 15370 -860 15390 {
lab=#net27}
N -3410 15490 -3250 15490 {
lab=#net21}
N -3250 15490 -3250 15610 {
lab=#net21}
N -3250 15610 -3050 15610 {
lab=#net21}
N -2720 15520 -2530 15520 {
lab=#net23}
N -2530 15520 -2530 15610 {
lab=#net23}
N -2530 15610 -2360 15610 {
lab=#net23}
N -2020 15520 -1850 15520 {
lab=#net25}
N -1850 15520 -1850 15610 {
lab=#net25}
N -1850 15610 -1710 15610 {
lab=#net25}
N -1370 15520 -1060 15520 {
lab=o1}
N -1060 15520 -1060 15610 {
lab=o1}
N -1060 15610 -950 15600 {
lab=o1}
N -3660 15310 -3660 15350 {
lab=#net22}
N -2960 15340 -2960 15390 {
lab=#net24}
N -2270 15320 -2270 15380 {
lab=#net22}
N -1620 15370 -1620 15390 {
lab=#net26}
N -860 15340 -860 15360 {
lab=#net27}
N -860 15360 -860 15370 {
lab=#net27}
N 110 16320 110 16330 {
lab=clk_in}
N 110 16160 110 16320 {
lab=clk_in}
N 90 16220 110 16220 {
lab=clk_in}
N -210 16180 -210 16240 {
lab=#net28}
N -210 16240 70 16240 {
lab=#net28}
N 70 16240 70 16310 {
lab=#net28}
N 50 16310 70 16310 {
lab=#net28}
N -210 16140 -210 16170 {
lab=#net28}
N -210 16170 -210 16180 {
lab=#net28}
N 90 16100 90 16220 {
lab=clk_in}
N -330 16350 -250 16350 {
lab=#net29}
N -590 16510 -590 16530 {
lab=#net30}
N -610 16250 -590 16250 {
lab=#net29}
N -910 16210 -910 16270 {
lab=#net31}
N -910 16270 -630 16270 {
lab=#net31}
N -630 16270 -630 16340 {
lab=#net31}
N -650 16340 -630 16340 {
lab=#net31}
N -910 16170 -910 16200 {
lab=#net31}
N -910 16200 -910 16210 {
lab=#net31}
N -610 16130 -610 16250 {
lab=#net29}
N -1030 16380 -950 16380 {
lab=#net30}
N -1280 16350 -1280 16360 {
lab=#net30}
N -1280 16510 -1280 16530 {
lab=#net32}
N -1300 16250 -1280 16250 {
lab=#net30}
N -1600 16210 -1600 16270 {
lab=#net33}
N -1600 16270 -1320 16270 {
lab=#net33}
N -1320 16270 -1320 16340 {
lab=#net33}
N -1340 16340 -1320 16340 {
lab=#net33}
N -1600 16170 -1600 16200 {
lab=#net33}
N -1600 16200 -1600 16210 {
lab=#net33}
N -1300 16130 -1300 16250 {
lab=#net30}
N -1720 16380 -1640 16380 {
lab=#net32}
N -1950 16250 -1930 16250 {
lab=#net32}
N -2250 16210 -2250 16270 {
lab=#net34}
N -2250 16270 -1970 16270 {
lab=#net34}
N -1970 16270 -1970 16340 {
lab=#net34}
N -1990 16340 -1970 16340 {
lab=#net34}
N -2250 16170 -2250 16200 {
lab=#net34}
N -2250 16200 -2250 16210 {
lab=#net34}
N -1950 16130 -1950 16250 {
lab=#net32}
N -2370 16380 -2290 16380 {
lab=#net35}
N -2940 16650 -2900 16650 {
lab=o7}
N -2690 16340 -2690 16350 {
lab=#net35}
N -2690 16500 -2690 16520 {
lab=#net36}
N -2710 16240 -2690 16240 {
lab=#net35}
N -3010 16200 -3010 16260 {
lab=#net37}
N -3010 16260 -2730 16260 {
lab=#net37}
N -2730 16260 -2730 16330 {
lab=#net37}
N -2750 16330 -2730 16330 {
lab=#net37}
N -3010 16160 -3010 16190 {
lab=#net37}
N -3010 16190 -3010 16200 {
lab=#net37}
N -2710 16120 -2710 16240 {
lab=#net35}
N -3130 16370 -3050 16370 {
lab=#net36}
N -2490 16650 -2490 16740 {
lab=o6}
N -1280 16380 -1030 16380 {
lab=#net30}
N -1930 16380 -1720 16380 {
lab=#net32}
N -2690 16380 -2370 16380 {
lab=#net35}
N -300 16350 -300 16440 {
lab=#net29}
N -300 16440 110 16440 {
lab=#net29}
N -590 16250 -590 16350 {
lab=#net29}
N -1030 16380 -1030 16470 {
lab=#net30}
N -1030 16470 -590 16470 {
lab=#net30}
N -590 16470 -590 16520 {
lab=#net30}
N -1280 16360 -1280 16380 {
lab=#net30}
N -1280 16250 -1280 16360 {
lab=#net30}
N -1780 16380 -1780 16450 {
lab=#net32}
N -1780 16450 -1280 16450 {
lab=#net32}
N -1280 16450 -1280 16510 {
lab=#net32}
N -1930 16250 -1930 16380 {
lab=#net32}
N -2440 16380 -2440 16500 {
lab=#net35}
N -2440 16500 -1930 16500 {
lab=#net35}
N -1930 16500 -1930 16520 {
lab=#net35}
N -2690 16350 -2690 16380 {
lab=#net35}
N -2690 16230 -2690 16350 {
lab=#net35}
N -3130 16370 -3130 16470 {
lab=#net36}
N -3130 16470 -2690 16470 {
lab=#net36}
N -2690 16470 -2690 16490 {
lab=#net36}
N -2690 16490 -2690 16500 {
lab=#net36}
N -590 16350 -330 16350 {
lab=#net29}
N 120 16440 120 16500 {
lab=#net29}
N 90 16440 120 16440 {
lab=#net29}
N -590 16530 -580 16530 {
lab=#net30}
N -1280 16530 -1270 16530 {
lab=#net32}
N -1930 16520 -1930 16530 {
lab=#net35}
N -1930 16530 -1920 16530 {
lab=#net35}
N -2690 16520 -2680 16520 {
lab=#net36}
N -2600 16740 -2490 16740 {
lab=o6}
N -2490 16660 -2140 16660 {
lab=o6}
N -1840 16750 -1490 16750 {
lab=o5}
N -1490 16660 -1490 16750 {
lab=o5}
N -1190 16750 -800 16750 {
lab=o4}
N -800 16660 -800 16750 {
lab=o4}
N -500 16750 -100 16750 {
lab=o3}
N -100 16630 -100 16750 {
lab=o3}
N -610 15510 290 15510 {
lab=o2}
N 290 15510 290 16720 {
lab=o2}
N 200 16720 290 16720 {
lab=o2}
N -3290 17300 -3290 17310 {
lab=clk_in}
N -3290 17140 -3290 17300 {
lab=clk_in}
N -3290 17200 -3270 17200 {
lab=clk_in}
N -2970 17160 -2970 17220 {
lab=#net38}
N -3250 17220 -2970 17220 {
lab=#net38}
N -3250 17220 -3250 17290 {
lab=#net38}
N -3250 17290 -3230 17290 {
lab=#net38}
N -2970 17120 -2970 17150 {
lab=#net38}
N -2970 17150 -2970 17160 {
lab=#net38}
N -3270 17080 -3270 17200 {
lab=clk_in}
N -2930 17330 -2850 17330 {
lab=#net39}
N -2590 17490 -2590 17510 {
lab=#net40}
N -2590 17230 -2570 17230 {
lab=#net39}
N -2270 17190 -2270 17250 {
lab=#net41}
N -2550 17250 -2270 17250 {
lab=#net41}
N -2550 17250 -2550 17320 {
lab=#net41}
N -2550 17320 -2530 17320 {
lab=#net41}
N -2270 17150 -2270 17180 {
lab=#net41}
N -2270 17180 -2270 17190 {
lab=#net41}
N -2570 17110 -2570 17230 {
lab=#net39}
N -2230 17360 -2150 17360 {
lab=#net40}
N -1900 17330 -1900 17340 {
lab=#net40}
N -1900 17490 -1900 17510 {
lab=#net42}
N -1900 17230 -1880 17230 {
lab=#net40}
N -1580 17190 -1580 17250 {
lab=#net43}
N -1860 17250 -1580 17250 {
lab=#net43}
N -1860 17250 -1860 17320 {
lab=#net43}
N -1860 17320 -1840 17320 {
lab=#net43}
N -1580 17150 -1580 17180 {
lab=#net43}
N -1580 17180 -1580 17190 {
lab=#net43}
N -1880 17110 -1880 17230 {
lab=#net40}
N -1540 17360 -1460 17360 {
lab=#net42}
N -1250 17230 -1230 17230 {
lab=#net42}
N -930 17190 -930 17250 {
lab=#net44}
N -1210 17250 -930 17250 {
lab=#net44}
N -1210 17250 -1210 17320 {
lab=#net44}
N -1210 17320 -1190 17320 {
lab=#net44}
N -930 17150 -930 17180 {
lab=#net44}
N -930 17180 -930 17190 {
lab=#net44}
N -1230 17110 -1230 17230 {
lab=#net42}
N -890 17360 -810 17360 {
lab=#net45}
N -280 17630 -240 17630 {
lab=out1}
N -490 17320 -490 17330 {
lab=#net45}
N -490 17480 -490 17500 {
lab=#net46}
N -490 17220 -470 17220 {
lab=#net45}
N -170 17180 -170 17240 {
lab=#net47}
N -450 17240 -170 17240 {
lab=#net47}
N -450 17240 -450 17310 {
lab=#net47}
N -450 17310 -430 17310 {
lab=#net47}
N -170 17140 -170 17170 {
lab=#net47}
N -170 17170 -170 17180 {
lab=#net47}
N -470 17100 -470 17220 {
lab=#net45}
N -130 17350 -50 17350 {
lab=#net46}
N -690 17630 -690 17720 {
lab=o11}
N -2150 17360 -1900 17360 {
lab=#net40}
N -1460 17360 -1250 17360 {
lab=#net42}
N -810 17360 -490 17360 {
lab=#net45}
N -2880 17330 -2880 17420 {
lab=#net39}
N -3290 17420 -2880 17420 {
lab=#net39}
N -2590 17230 -2590 17330 {
lab=#net39}
N -2150 17360 -2150 17450 {
lab=#net40}
N -2590 17450 -2150 17450 {
lab=#net40}
N -2590 17450 -2590 17500 {
lab=#net40}
N -1900 17340 -1900 17360 {
lab=#net40}
N -1900 17230 -1900 17340 {
lab=#net40}
N -1400 17360 -1400 17430 {
lab=#net42}
N -1900 17430 -1400 17430 {
lab=#net42}
N -1900 17430 -1900 17490 {
lab=#net42}
N -1250 17230 -1250 17360 {
lab=#net42}
N -740 17360 -740 17480 {
lab=#net45}
N -1250 17480 -740 17480 {
lab=#net45}
N -1250 17480 -1250 17500 {
lab=#net45}
N -490 17330 -490 17360 {
lab=#net45}
N -490 17210 -490 17330 {
lab=#net45}
N -50 17350 -50 17450 {
lab=#net46}
N -490 17450 -50 17450 {
lab=#net46}
N -490 17450 -490 17470 {
lab=#net46}
N -490 17470 -490 17480 {
lab=#net46}
N -2850 17330 -2590 17330 {
lab=#net39}
N -3300 17420 -3300 17480 {
lab=#net39}
N -3300 17420 -3270 17420 {
lab=#net39}
N -2600 17510 -2590 17510 {
lab=#net40}
N -1910 17510 -1900 17510 {
lab=#net42}
N -1250 17500 -1250 17510 {
lab=#net45}
N -1260 17510 -1250 17510 {
lab=#net45}
N -500 17500 -490 17500 {
lab=#net46}
N -690 17720 -580 17720 {
lab=o11}
N -1040 17640 -690 17640 {
lab=o11}
N -1690 17730 -1340 17730 {
lab=o10}
N -1690 17640 -1690 17730 {
lab=o10}
N -2380 17730 -1990 17730 {
lab=o9}
N -2380 17640 -2380 17730 {
lab=o9}
N -3080 17730 -2680 17730 {
lab=o8}
N -3080 17610 -3080 17730 {
lab=o8}
N -3350 16650 -2930 16650 {
lab=o7}
N -3570 16650 -3350 16650 {
lab=o7}
N -3590 17680 -3570 16650 {
lab=o7}
N -3590 17680 -3590 17700 {
lab=o7}
N -3590 17700 -3380 17700 {
lab=o7}
N -4640 16560 -4640 16800 {
lab=Q3}
N -4310 16960 -4260 16960 {
lab=reset}
N -4300 16980 -4260 16980 {
lab=scan_en}
N -4300 17000 -4260 17000 {
lab=scan_in}
N -4310 17030 -4260 17030 {
lab=#net48}
N -4110 16820 -4110 16840 {
lab=Vdd}
N -4110 17100 -4110 17120 {
lab=GND}
N -4310 16870 -4260 16870 {
lab=clk}
N -4320 16980 -4300 16980 {
lab=scan_en}
N -4320 16960 -4310 16960 {
lab=reset}
N -4640 16880 -4640 17020 {
lab=#net48}
N -4640 17020 -4640 17030 {
lab=#net48}
N -4640 17030 -4310 17030 {
lab=#net48}
N -4480 16360 -4480 16930 {
lab=#net20}
N -4480 16930 -4260 16930 {
lab=#net20}
N -3880 16110 -3840 16110 {
lab=#net49}
N -3400 18780 -3360 18780 {
lab=#net50}
N -3610 18480 -3610 18490 {
lab=clk_in}
N -3610 18640 -3610 18660 {
lab=#net51}
N -3610 18320 -3610 18480 {
lab=clk_in}
N -3610 18380 -3590 18380 {
lab=clk_in}
N -3290 18340 -3290 18400 {
lab=#net52}
N -3570 18400 -3290 18400 {
lab=#net52}
N -3570 18400 -3570 18470 {
lab=#net52}
N -3570 18470 -3550 18470 {
lab=#net52}
N -3290 18300 -3290 18330 {
lab=#net52}
N -3290 18330 -3290 18340 {
lab=#net52}
N -3590 18260 -3590 18380 {
lab=clk_in}
N -3250 18510 -3170 18510 {
lab=#net51}
N -2700 18810 -2660 18810 {
lab=#net53}
N -2910 18670 -2910 18690 {
lab=#net54}
N -2910 18410 -2890 18410 {
lab=#net51}
N -2590 18370 -2590 18430 {
lab=#net55}
N -2870 18430 -2590 18430 {
lab=#net55}
N -2870 18430 -2870 18500 {
lab=#net55}
N -2870 18500 -2850 18500 {
lab=#net55}
N -2590 18330 -2590 18360 {
lab=#net55}
N -2590 18360 -2590 18370 {
lab=#net55}
N -2890 18290 -2890 18410 {
lab=#net51}
N -2550 18540 -2470 18540 {
lab=#net54}
N -2010 18810 -1970 18810 {
lab=#net56}
N -2220 18510 -2220 18520 {
lab=#net54}
N -2220 18670 -2220 18690 {
lab=#net57}
N -2220 18410 -2200 18410 {
lab=#net54}
N -1900 18370 -1900 18430 {
lab=#net58}
N -2180 18430 -1900 18430 {
lab=#net58}
N -2180 18430 -2180 18500 {
lab=#net58}
N -2180 18500 -2160 18500 {
lab=#net58}
N -1900 18330 -1900 18360 {
lab=#net58}
N -1900 18360 -1900 18370 {
lab=#net58}
N -2200 18290 -2200 18410 {
lab=#net54}
N -1860 18540 -1780 18540 {
lab=#net57}
N -1360 18810 -1320 18810 {
lab=ob1}
N -1570 18670 -1570 18690 {
lab=#net59}
N -1570 18410 -1550 18410 {
lab=#net57}
N -1250 18370 -1250 18430 {
lab=#net60}
N -1530 18430 -1250 18430 {
lab=#net60}
N -1530 18430 -1530 18500 {
lab=#net60}
N -1530 18500 -1510 18500 {
lab=#net60}
N -1250 18330 -1250 18360 {
lab=#net60}
N -1250 18360 -1250 18370 {
lab=#net60}
N -1550 18290 -1550 18410 {
lab=#net57}
N -1210 18540 -1130 18540 {
lab=#net59}
N -600 18800 -560 18800 {
lab=ob2}
N -810 18500 -810 18510 {
lab=#net59}
N -810 18660 -810 18680 {
lab=#net61}
N -810 18400 -790 18400 {
lab=#net59}
N -490 18360 -490 18420 {
lab=#net62}
N -770 18420 -490 18420 {
lab=#net62}
N -770 18420 -770 18490 {
lab=#net62}
N -770 18490 -750 18490 {
lab=#net62}
N -490 18320 -490 18350 {
lab=#net62}
N -490 18350 -490 18360 {
lab=#net62}
N -790 18280 -790 18400 {
lab=#net59}
N -450 18530 -370 18530 {
lab=#net61}
N -3360 18780 -3200 18780 {
lab=#net50}
N -3200 18780 -3200 18900 {
lab=#net50}
N -3200 18900 -3000 18900 {
lab=#net50}
N -2670 18810 -2480 18810 {
lab=#net53}
N -2480 18810 -2480 18900 {
lab=#net53}
N -2480 18900 -2310 18900 {
lab=#net53}
N -1970 18810 -1800 18810 {
lab=#net56}
N -1800 18810 -1800 18900 {
lab=#net56}
N -1800 18900 -1660 18900 {
lab=#net56}
N -1320 18810 -1010 18810 {
lab=ob1}
N -1010 18810 -1010 18900 {
lab=ob1}
N -1010 18900 -900 18890 {
lab=ob1}
N -2470 18540 -2220 18540 {
lab=#net54}
N -1780 18540 -1570 18540 {
lab=#net57}
N -1130 18540 -810 18540 {
lab=#net59}
N -3200 18510 -3200 18600 {
lab=#net51}
N -3610 18600 -3200 18600 {
lab=#net51}
N -3610 18600 -3610 18640 {
lab=#net51}
N -2910 18410 -2910 18510 {
lab=#net51}
N -2470 18540 -2470 18630 {
lab=#net54}
N -2910 18630 -2470 18630 {
lab=#net54}
N -2910 18630 -2910 18680 {
lab=#net54}
N -2220 18520 -2220 18540 {
lab=#net54}
N -2220 18410 -2220 18520 {
lab=#net54}
N -1720 18540 -1720 18610 {
lab=#net57}
N -2220 18610 -1720 18610 {
lab=#net57}
N -2220 18610 -2220 18670 {
lab=#net57}
N -1570 18410 -1570 18540 {
lab=#net57}
N -1060 18540 -1060 18660 {
lab=#net59}
N -1570 18660 -1060 18660 {
lab=#net59}
N -1570 18660 -1570 18680 {
lab=#net59}
N -810 18510 -810 18540 {
lab=#net59}
N -810 18390 -810 18510 {
lab=#net59}
N -370 18530 -370 18630 {
lab=#net61}
N -810 18630 -370 18630 {
lab=#net61}
N -810 18630 -810 18650 {
lab=#net61}
N -810 18650 -810 18660 {
lab=#net61}
N -3170 18510 -2910 18510 {
lab=#net51}
N 160 19610 160 19620 {
lab=clk_in}
N 160 19450 160 19610 {
lab=clk_in}
N 140 19510 160 19510 {
lab=clk_in}
N -160 19470 -160 19530 {
lab=#net63}
N -160 19530 120 19530 {
lab=#net63}
N 120 19530 120 19600 {
lab=#net63}
N 100 19600 120 19600 {
lab=#net63}
N -160 19430 -160 19460 {
lab=#net63}
N -160 19460 -160 19470 {
lab=#net63}
N 140 19390 140 19510 {
lab=clk_in}
N -280 19640 -200 19640 {
lab=#net64}
N -540 19800 -540 19820 {
lab=#net65}
N -560 19540 -540 19540 {
lab=#net64}
N -860 19500 -860 19560 {
lab=#net66}
N -860 19560 -580 19560 {
lab=#net66}
N -580 19560 -580 19630 {
lab=#net66}
N -600 19630 -580 19630 {
lab=#net66}
N -860 19460 -860 19490 {
lab=#net66}
N -860 19490 -860 19500 {
lab=#net66}
N -560 19420 -560 19540 {
lab=#net64}
N -980 19670 -900 19670 {
lab=#net65}
N -1230 19640 -1230 19650 {
lab=#net65}
N -1230 19800 -1230 19820 {
lab=#net67}
N -1250 19540 -1230 19540 {
lab=#net65}
N -1550 19500 -1550 19560 {
lab=#net68}
N -1550 19560 -1270 19560 {
lab=#net68}
N -1270 19560 -1270 19630 {
lab=#net68}
N -1290 19630 -1270 19630 {
lab=#net68}
N -1550 19460 -1550 19490 {
lab=#net68}
N -1550 19490 -1550 19500 {
lab=#net68}
N -1250 19420 -1250 19540 {
lab=#net65}
N -1670 19670 -1590 19670 {
lab=#net67}
N -1900 19540 -1880 19540 {
lab=#net67}
N -2200 19500 -2200 19560 {
lab=#net69}
N -2200 19560 -1920 19560 {
lab=#net69}
N -1920 19560 -1920 19630 {
lab=#net69}
N -1940 19630 -1920 19630 {
lab=#net69}
N -2200 19460 -2200 19490 {
lab=#net69}
N -2200 19490 -2200 19500 {
lab=#net69}
N -1900 19420 -1900 19540 {
lab=#net67}
N -2320 19670 -2240 19670 {
lab=#net70}
N -2890 19940 -2850 19940 {
lab=ob7}
N -2640 19630 -2640 19640 {
lab=#net70}
N -2640 19790 -2640 19810 {
lab=#net71}
N -2660 19530 -2640 19530 {
lab=#net70}
N -2960 19490 -2960 19550 {
lab=#net72}
N -2960 19550 -2680 19550 {
lab=#net72}
N -2680 19550 -2680 19620 {
lab=#net72}
N -2700 19620 -2680 19620 {
lab=#net72}
N -2960 19450 -2960 19480 {
lab=#net72}
N -2960 19480 -2960 19490 {
lab=#net72}
N -2660 19410 -2660 19530 {
lab=#net70}
N -3080 19660 -3000 19660 {
lab=#net71}
N -2440 19940 -2440 20030 {
lab=ob6}
N -1230 19670 -980 19670 {
lab=#net65}
N -1880 19670 -1670 19670 {
lab=#net67}
N -2640 19670 -2320 19670 {
lab=#net70}
N -250 19640 -250 19730 {
lab=#net64}
N -250 19730 160 19730 {
lab=#net64}
N -540 19540 -540 19640 {
lab=#net64}
N -980 19670 -980 19760 {
lab=#net65}
N -980 19760 -540 19760 {
lab=#net65}
N -540 19760 -540 19810 {
lab=#net65}
N -1230 19650 -1230 19670 {
lab=#net65}
N -1230 19540 -1230 19650 {
lab=#net65}
N -1730 19670 -1730 19740 {
lab=#net67}
N -1730 19740 -1230 19740 {
lab=#net67}
N -1230 19740 -1230 19800 {
lab=#net67}
N -1880 19540 -1880 19670 {
lab=#net67}
N -2390 19670 -2390 19790 {
lab=#net70}
N -2390 19790 -1880 19790 {
lab=#net70}
N -1880 19790 -1880 19810 {
lab=#net70}
N -2640 19640 -2640 19670 {
lab=#net70}
N -2640 19520 -2640 19640 {
lab=#net70}
N -3080 19660 -3080 19760 {
lab=#net71}
N -3080 19760 -2640 19760 {
lab=#net71}
N -2640 19760 -2640 19780 {
lab=#net71}
N -2640 19780 -2640 19790 {
lab=#net71}
N -540 19640 -280 19640 {
lab=#net64}
N 170 19730 170 19790 {
lab=#net64}
N 140 19730 170 19730 {
lab=#net64}
N -540 19820 -530 19820 {
lab=#net65}
N -1230 19820 -1220 19820 {
lab=#net67}
N -1880 19810 -1880 19820 {
lab=#net70}
N -1880 19820 -1870 19820 {
lab=#net70}
N -2640 19810 -2630 19810 {
lab=#net71}
N -2550 20030 -2440 20030 {
lab=ob6}
N -2440 19950 -2090 19950 {
lab=ob6}
N -1790 20040 -1440 20040 {
lab=ob5}
N -1440 19950 -1440 20040 {
lab=ob5}
N -1140 20040 -750 20040 {
lab=ob4}
N -750 19950 -750 20040 {
lab=ob4}
N -450 20040 -50 20040 {
lab=ob3}
N -50 19920 -50 20040 {
lab=ob3}
N -560 18800 340 18800 {
lab=ob2}
N 340 18800 340 20010 {
lab=ob2}
N 250 20010 340 20010 {
lab=ob2}
N -3240 20590 -3240 20600 {
lab=clk_in}
N -3240 20430 -3240 20590 {
lab=clk_in}
N -3240 20490 -3220 20490 {
lab=clk_in}
N -2920 20450 -2920 20510 {
lab=#net73}
N -3200 20510 -2920 20510 {
lab=#net73}
N -3200 20510 -3200 20580 {
lab=#net73}
N -3200 20580 -3180 20580 {
lab=#net73}
N -2920 20410 -2920 20440 {
lab=#net73}
N -2920 20440 -2920 20450 {
lab=#net73}
N -3220 20370 -3220 20490 {
lab=clk_in}
N -2880 20620 -2800 20620 {
lab=#net74}
N -2540 20780 -2540 20800 {
lab=#net75}
N -2540 20520 -2520 20520 {
lab=#net74}
N -2220 20480 -2220 20540 {
lab=#net76}
N -2500 20540 -2220 20540 {
lab=#net76}
N -2500 20540 -2500 20610 {
lab=#net76}
N -2500 20610 -2480 20610 {
lab=#net76}
N -2220 20440 -2220 20470 {
lab=#net76}
N -2220 20470 -2220 20480 {
lab=#net76}
N -2520 20400 -2520 20520 {
lab=#net74}
N -2180 20650 -2100 20650 {
lab=#net75}
N -1850 20620 -1850 20630 {
lab=#net75}
N -1850 20780 -1850 20800 {
lab=#net77}
N -1850 20520 -1830 20520 {
lab=#net75}
N -1530 20480 -1530 20540 {
lab=#net78}
N -1810 20540 -1530 20540 {
lab=#net78}
N -1810 20540 -1810 20610 {
lab=#net78}
N -1810 20610 -1790 20610 {
lab=#net78}
N -1530 20440 -1530 20470 {
lab=#net78}
N -1530 20470 -1530 20480 {
lab=#net78}
N -1830 20400 -1830 20520 {
lab=#net75}
N -1490 20650 -1410 20650 {
lab=#net77}
N -1200 20520 -1180 20520 {
lab=#net77}
N -880 20480 -880 20540 {
lab=#net79}
N -1160 20540 -880 20540 {
lab=#net79}
N -1160 20540 -1160 20610 {
lab=#net79}
N -1160 20610 -1140 20610 {
lab=#net79}
N -880 20440 -880 20470 {
lab=#net79}
N -880 20470 -880 20480 {
lab=#net79}
N -1180 20400 -1180 20520 {
lab=#net77}
N -840 20650 -760 20650 {
lab=#net80}
N -230 20920 -190 20920 {
lab=out2}
N -440 20610 -440 20620 {
lab=#net80}
N -440 20770 -440 20790 {
lab=#net81}
N -440 20510 -420 20510 {
lab=#net80}
N -120 20470 -120 20530 {
lab=#net82}
N -400 20530 -120 20530 {
lab=#net82}
N -400 20530 -400 20600 {
lab=#net82}
N -400 20600 -380 20600 {
lab=#net82}
N -120 20430 -120 20460 {
lab=#net82}
N -120 20460 -120 20470 {
lab=#net82}
N -420 20390 -420 20510 {
lab=#net80}
N -80 20640 0 20640 {
lab=#net81}
N -640 20920 -640 21010 {
lab=#net83}
N -2100 20650 -1850 20650 {
lab=#net75}
N -1410 20650 -1200 20650 {
lab=#net77}
N -760 20650 -440 20650 {
lab=#net80}
N -2830 20620 -2830 20710 {
lab=#net74}
N -3240 20710 -2830 20710 {
lab=#net74}
N -2540 20520 -2540 20620 {
lab=#net74}
N -2100 20650 -2100 20740 {
lab=#net75}
N -2540 20740 -2100 20740 {
lab=#net75}
N -2540 20740 -2540 20790 {
lab=#net75}
N -1850 20630 -1850 20650 {
lab=#net75}
N -1850 20520 -1850 20630 {
lab=#net75}
N -1350 20650 -1350 20720 {
lab=#net77}
N -1850 20720 -1350 20720 {
lab=#net77}
N -1850 20720 -1850 20780 {
lab=#net77}
N -1200 20520 -1200 20650 {
lab=#net77}
N -690 20650 -690 20770 {
lab=#net80}
N -1200 20770 -690 20770 {
lab=#net80}
N -1200 20770 -1200 20790 {
lab=#net80}
N -440 20620 -440 20650 {
lab=#net80}
N -440 20500 -440 20620 {
lab=#net80}
N 0 20640 0 20740 {
lab=#net81}
N -440 20740 0 20740 {
lab=#net81}
N -440 20740 -440 20760 {
lab=#net81}
N -440 20760 -440 20770 {
lab=#net81}
N -2800 20620 -2540 20620 {
lab=#net74}
N -3250 20710 -3250 20770 {
lab=#net74}
N -3250 20710 -3220 20710 {
lab=#net74}
N -2550 20800 -2540 20800 {
lab=#net75}
N -1860 20800 -1850 20800 {
lab=#net77}
N -1200 20790 -1200 20800 {
lab=#net80}
N -1210 20800 -1200 20800 {
lab=#net80}
N -450 20790 -440 20790 {
lab=#net81}
N -640 21010 -530 21010 {
lab=#net83}
N -990 20930 -640 20930 {
lab=#net83}
N -1640 21020 -1290 21020 {
lab=ob10}
N -1640 20930 -1640 21020 {
lab=ob10}
N -2330 21020 -1940 21020 {
lab=ob9}
N -2330 20930 -2330 21020 {
lab=ob9}
N -3030 21020 -2630 21020 {
lab=ob8}
N -3030 20900 -3030 21020 {
lab=ob8}
N -3300 19940 -2880 19940 {
lab=ob7}
N -3520 19940 -3300 19940 {
lab=ob7}
N -3540 20970 -3520 19940 {
lab=ob7}
N -3540 20970 -3540 20990 {
lab=ob7}
N -3540 20990 -3330 20990 {
lab=ob7}
N 1550 16010 1550 16090 {
lab=#net84}
N 1730 16010 1730 16090 {
lab=Vbcmfb}
N 1550 15930 1550 15950 {
lab=#net85}
N 1730 15930 1730 15950 {
lab=#net85}
N 1550 16150 1550 16170 {
lab=gnd}
N 1550 16170 1730 16170 {
lab=gnd}
N 1730 16150 1730 16170 {
lab=gnd}
N 1590 15980 1690 15980 {
lab=Vdd}
N 1550 16050 1630 16050 {
lab=#net84}
N 1150 15910 1150 15940 {
lab=Vdd}
N 1150 15910 1340 15910 {
lab=Vdd}
N 1340 15910 1340 15940 {
lab=Vdd}
N 1150 16000 1150 16080 {
lab=Vcm_det3}
N 1340 16000 1340 16080 {
lab=Vcm_det3}
N 1090 15970 1110 15970 {
lab=outr1}
N 1090 15970 1090 16110 {
lab=outr1}
N 1090 16110 1110 16110 {
lab=outr1}
N 1380 15970 1400 15970 {
lab=outr2}
N 1400 15970 1400 16110 {
lab=outr2}
N 1380 16110 1400 16110 {
lab=outr2}
N 1950 15940 1950 15970 {
lab=Vdd}
N 1950 15940 2140 15940 {
lab=Vdd}
N 2140 15940 2140 15970 {
lab=Vdd}
N 1950 16030 1950 16110 {
lab=Vcm3}
N 2140 16030 2140 16110 {
lab=Vcm3}
N 1950 16170 1950 16200 {
lab=gnd}
N 2140 16170 2140 16200 {
lab=gnd}
N 1890 16000 1910 16000 {
lab=Vc2+}
N 1890 16000 1890 16140 {
lab=Vc2+}
N 1890 16140 1910 16140 {
lab=Vc2+}
N 2180 16000 2200 16000 {
lab=Vc2+}
N 2200 16000 2200 16140 {
lab=Vc2+}
N 2180 16140 2200 16140 {
lab=Vc2+}
N 1150 16040 1340 16040 {
lab=Vcm_det3}
N 1950 16070 2140 16070 {
lab=Vcm3}
N 1350 15800 1530 15800 {
lab=Vdd}
N 1950 16200 2140 16200 {
lab=gnd}
N 1480 16270 1480 16290 {
lab=gnd}
N 1480 16290 1780 16290 {
lab=gnd}
N 1780 16260 1780 16290 {
lab=gnd}
N 1440 16240 1440 16290 {
lab=gnd}
N 1440 16290 1480 16290 {
lab=gnd}
N 1480 16210 1520 16210 {
lab=gnd}
N 1520 16210 1520 16290 {
lab=gnd}
N 1820 16230 1820 16290 {
lab=gnd}
N 1780 16290 1820 16290 {
lab=gnd}
N 1730 16200 1780 16200 {
lab=gnd}
N 1730 16200 1730 16290 {
lab=gnd}
N 1310 15780 1310 15800 {
lab=Vdd}
N 1310 15800 1370 15800 {
lab=Vdd}
N 1520 15780 1520 15800 {
lab=Vdd}
N 1350 15750 1350 15800 {
lab=Vdd}
N 1480 15750 1480 15800 {
lab=Vdd}
N 1310 15720 1390 15720 {
lab=Vdd}
N 1390 15720 1390 15800 {
lab=Vdd}
N 1440 15720 1520 15720 {
lab=Vdd}
N 1440 15720 1440 15800 {
lab=Vdd}
N 1150 16140 1150 16170 {
lab=gnd}
N 1150 16170 1340 16170 {
lab=gnd}
N 1340 16140 1340 16170 {
lab=gnd}
N 1310 15750 1310 15800 {
lab=Vdd}
N 1520 15750 1520 15790 {
lab=Vdd}
N 1480 16240 1480 16280 {
lab=gnd}
N 1780 16230 1780 16270 {
lab=gnd}
N 1150 15970 1200 15970 {
lab=gnd}
N 1270 15970 1340 15970 {
lab=gnd}
N 1200 15970 1270 15970 {
lab=gnd}
N 1150 16110 1340 16110 {
lab=Vdd}
N 1950 16000 2140 16000 {
lab=gnd}
N 1950 16140 2140 16140 {
lab=Vdd}
N 1590 16120 1690 16120 {
lab=#net84}
N 1730 16120 1730 16160 {
lab=gnd}
N 1550 16120 1550 16160 {
lab=gnd}
N 1550 15980 1590 15980 {
lab=Vdd}
N 1690 15980 1730 15980 {
lab=Vdd}
N 1630 16050 1630 16120 {
lab=#net84}
N 1470 15980 1510 15980 {
lab=Vcm_det3}
N 1770 15980 1830 15980 {
lab=Vcm3}
N 1550 15930 1730 15930 {
lab=#net85}
N 1640 15890 1640 15930 {
lab=#net85}
N 1640 15790 1640 15830 {
lab=Vdd}
N 1550 15860 1600 15860 {
lab=Vbiasp}
N 1240 16220 1240 16240 {
lab=Vdd}
N 1240 16300 1240 16340 {
lab=Vbiasp}
N 1200 16270 1200 16320 {
lab=Vbiasp}
N 1200 16320 1240 16320 {
lab=Vbiasp}
N 1240 16340 1240 16380 {
lab=Vbiasp}
N 1180 16410 1200 16410 {
lab=Vbias1}
N 1180 16360 1180 16410 {
lab=Vbias1}
N 1240 16440 1240 16460 {
lab=GND}
N 1240 16410 1240 16450 {
lab=GND}
N 1230 16270 1240 16270 {
lab=Vdd}
N 1240 16230 1240 16270 {
lab=Vdd}
N -7920 15830 -7920 15870 {
lab=Vc1-}
N -7920 15750 -7920 15770 {
lab=Vc1+}
N -7920 15800 -7900 15800 {
lab=Vc1+}
N -7920 15760 -7900 15760 {
lab=Vc1+}
N -7920 15900 -7890 15900 {
lab=Vc1-}
N -7920 15860 -7890 15860 {
lab=Vc1-}
N -7980 15800 -7960 15800 {
lab=Vc1-}
N -7980 15900 -7960 15900 {
lab=gnd}
N -7980 15800 -7980 15840 {
lab=Vc1-}
N -7980 15840 -7920 15840 {
lab=Vc1-}
N -7980 15900 -7980 15940 {
lab=gnd}
N -7980 15940 -7920 15940 {
lab=gnd}
N -7920 15720 -7920 15750 {
lab=Vc1+}
N -7890 15900 -7810 15900 {
lab=Vc1-}
N -7900 15800 -7810 15800 {
lab=Vc1+}
N -7810 15760 -7810 15800 {
lab=Vc1+}
N -7900 15760 -7810 15760 {
lab=Vc1+}
N -7810 15860 -7810 15900 {
lab=Vc1-}
N -7920 15630 -7920 15660 {
lab=vdd}
N -7980 15690 -7960 15690 {
lab=Vc1+}
N -7980 15690 -7980 15740 {
lab=Vc1+}
N -7980 15740 -7920 15740 {
lab=Vc1+}
N -7920 15690 -7860 15690 {
lab=vdd}
N -7860 15650 -7860 15690 {
lab=vdd}
N -7920 15940 -7920 15960 {
lab=gnd}
N -7860 15620 -7860 15650 {
lab=vdd}
N -7920 15620 -7860 15620 {
lab=vdd}
N -7920 15620 -7920 15630 {
lab=vdd}
N -7920 15930 -7920 15940 {
lab=gnd}
N -7890 15860 -7810 15860 {
lab=Vc1-}
N 2400 16110 2400 16150 {
lab=Vc2+}
N 2400 16180 2430 16180 {
lab=Vc2+}
N 2400 16140 2430 16140 {
lab=Vc2+}
N 2340 16180 2360 16180 {
lab=gnd}
N 2340 16180 2340 16220 {
lab=gnd}
N 2340 16220 2400 16220 {
lab=gnd}
N 2400 16000 2400 16030 {
lab=Vc2+}
N 2430 16180 2510 16180 {
lab=Vc2+}
N 2510 16140 2510 16180 {
lab=Vc2+}
N 2400 15910 2400 15940 {
lab=vdd}
N 2340 15970 2360 15970 {
lab=Vc2+}
N 2340 15970 2340 16020 {
lab=Vc2+}
N 2340 16020 2400 16020 {
lab=Vc2+}
N 2400 15970 2460 15970 {
lab=vdd}
N 2460 15930 2460 15970 {
lab=vdd}
N 2400 16220 2400 16240 {
lab=gnd}
N 2460 15900 2460 15930 {
lab=vdd}
N 2400 15900 2460 15900 {
lab=vdd}
N 2400 15900 2400 15910 {
lab=vdd}
N 2400 16210 2400 16220 {
lab=gnd}
N 2430 16140 2510 16140 {
lab=Vc2+}
N 2400 16030 2400 16120 {
lab=Vc2+}
N 1640 16410 1760 16410 {
lab=Vbcmfb}
N 1600 16330 1600 16380 {
lab=#net86}
N 1800 16330 1800 16380 {
lab=#net87}
N -4820 14940 -4820 14970 {
lab=Vdd}
N -4820 14940 -4630 14940 {
lab=Vdd}
N -4630 14940 -4630 14970 {
lab=Vdd}
N -4820 15030 -4820 15110 {
lab=vin+}
N -4630 15030 -4630 15110 {
lab=vin+}
N -4820 15170 -4820 15200 {
lab=GND}
N -4820 15200 -4630 15200 {
lab=GND}
N -4630 15170 -4630 15200 {
lab=GND}
N -4880 15000 -4860 15000 {
lab=vo1}
N -4880 15000 -4880 15140 {
lab=vo1}
N -4880 15140 -4860 15140 {
lab=vo1}
N -4590 15000 -4570 15000 {
lab=vo1}
N -4570 15000 -4570 15140 {
lab=vo1}
N -4590 15140 -4570 15140 {
lab=vo1}
N -4820 15070 -4630 15070 {
lab=vin+}
N -4820 15000 -4630 15000 {
lab=GND}
N -5100 17840 -5100 17870 {
lab=Vdd}
N -5100 17840 -4910 17840 {
lab=Vdd}
N -4910 17840 -4910 17870 {
lab=Vdd}
N -5100 17930 -5100 18010 {
lab=vin-}
N -4910 17930 -4910 18010 {
lab=vin-}
N -5100 18070 -5100 18100 {
lab=GND}
N -5100 18100 -4910 18100 {
lab=GND}
N -4910 18070 -4910 18100 {
lab=GND}
N -5160 17900 -5140 17900 {
lab=vo2}
N -5160 17900 -5160 18040 {
lab=vo2}
N -5160 18040 -5140 18040 {
lab=vo2}
N -4870 17900 -4850 17900 {
lab=vo2}
N -4850 17900 -4850 18040 {
lab=vo2}
N -4870 18040 -4850 18040 {
lab=vo2}
N -5100 17970 -4910 17970 {
lab=vin-}
N -5100 17900 -4910 17900 {
lab=GND}
N -3660 15320 -870 15320 {
lab=#net22}
C {devices/code.sym} -9500 17450 0 0 {name=TT_MODELS
only_toplevel=true
format="tcleval( @value )"
value="
** opencircuitdesign pdks install
.lib $::SKYWATER_MODELS/sky130.lib.spice tt

"
spice_ignore=false}
C {devices/lab_wire.sym} -8630 16460 0 0 {name=p30 sig_type=std_logic lab=Vbias

}
C {sky130_fd_pr/nfet_01v8.sym} -8590 16490 0 0 {name=M26
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} -8570 16550 0 0 {name=p31 sig_type=std_logic lab=gnd

}
C {sky130_fd_pr/pfet_01v8.sym} -8950 16350 0 1 {name=M27
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -8810 16350 0 0 {name=M28
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -8990 16250 0 1 {name=M29
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -8820 16250 0 0 {name=M30
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} -8960 16220 0 0 {name=p33 sig_type=std_logic lab=Vdd




}
C {devices/lab_wire.sym} -8860 16220 0 0 {name=p34 sig_type=std_logic lab=Vdd




}
C {devices/lab_wire.sym} -8960 16490 0 0 {name=p35 sig_type=std_logic lab=Vbias

}
C {sky130_fd_pr/nfet_01v8.sym} -8920 16520 0 0 {name=M31
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} -8900 16580 0 0 {name=p36 sig_type=std_logic lab=gnd

}
C {devices/lab_wire.sym} -8900 16460 0 0 {name=p37 sig_type=std_logic lab=Vs

}
C {devices/lab_wire.sym} -8970 16400 0 0 {name=p38 sig_type=std_logic lab=vin1


}
C {devices/lab_wire.sym} -8790 16400 0 0 {name=p39 sig_type=std_logic lab=vin2

}
C {sky130_fd_pr/cap_mim_m3_1.sym} -8900 16320 0 0 {name=C1 model=cap_mim_m3_1 W=10 L=10 MF=1 spiceprefix=X}
C {devices/lab_wire.sym} -9050 15810 0 0 {name=p42 sig_type=std_logic lab=Vcm_det1



}
C {devices/lab_wire.sym} -8270 15840 0 1 {name=p45 sig_type=std_logic lab=Vcm1




}
C {devices/lab_wire.sym} -8510 15890 0 1 {name=p46 sig_type=std_logic lab=Vcm1




}
C {devices/lab_wire.sym} -8810 15890 0 0 {name=p47 sig_type=std_logic lab=Vcm_det1



}
C {devices/lab_wire.sym} -8570 15820 0 0 {name=p48 sig_type=std_logic lab=Vbp




}
C {sky130_fd_pr/pfet_01v8.sym} -9170 15880 0 0 {name=M32
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -8940 15880 0 1 {name=M33
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -9170 15740 0 0 {name=M34
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -8940 15740 0 1 {name=M35
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -8730 15750 0 1 {name=M36
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -8590 15750 0 0 {name=M37
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -8770 15890 0 0 {name=M38
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -8550 15890 0 1 {name=M39
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -8680 16000 0 0 {name=M40
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -8370 15770 0 0 {name=M41
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -8140 15770 0 1 {name=M42
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -8370 15910 0 0 {name=M43
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -8140 15910 0 1 {name=M44
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -8840 16010 0 0 {name=M45
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -8500 16000 0 1 {name=M46
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -8770 15650 0 1 {name=M47
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -8600 15650 0 0 {name=M48
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} -9050 15680 0 0 {name=p49 sig_type=std_logic lab=Vdd




}
C {devices/lab_wire.sym} -8740 15620 0 0 {name=p50 sig_type=std_logic lab=Vdd




}
C {devices/lab_wire.sym} -8260 15710 0 0 {name=p51 sig_type=std_logic lab=Vdd




}
C {devices/lab_wire.sym} -9050 15940 0 0 {name=p52 sig_type=std_logic lab=gnd





}
C {devices/lab_wire.sym} -8690 16060 0 0 {name=p53 sig_type=std_logic lab=gnd





}
C {devices/lab_wire.sym} -8260 15970 0 0 {name=p54 sig_type=std_logic lab=gnd





}
C {devices/lab_wire.sym} -8640 15620 0 0 {name=p55 sig_type=std_logic lab=Vdd




}
C {devices/lab_wire.sym} -9030 15880 0 0 {name=p56 sig_type=std_logic lab=Vdd




}
C {devices/lab_wire.sym} -9060 15740 0 0 {name=p57 sig_type=std_logic lab=gnd





}
C {devices/lab_wire.sym} -8230 15910 0 0 {name=p58 sig_type=std_logic lab=Vdd




}
C {devices/lab_wire.sym} -8250 15770 0 0 {name=p59 sig_type=std_logic lab=gnd





}
C {devices/lab_wire.sym} -8660 15890 0 0 {name=p60 sig_type=std_logic lab=gnd





}
C {devices/lab_wire.sym} -8710 16000 0 0 {name=p61 sig_type=std_logic lab=Vbias

}
C {devices/lab_wire.sym} -9210 15820 0 0 {name=p40 sig_type=std_logic lab=vin1

}
C {devices/lab_wire.sym} -8900 15800 0 0 {name=p41 sig_type=std_logic lab=vin2

}
C {devices/lab_wire.sym} -8860 16350 0 0 {name=p62 sig_type=std_logic lab=Vbp




}
C {devices/lab_wire.sym} -7780 16180 0 0 {name=p2 sig_type=std_logic lab=Vdd
}
C {devices/lab_wire.sym} -8010 16420 0 0 {name=p7 sig_type=std_logic lab=vin1

}
C {devices/lab_wire.sym} -7550 16420 0 0 {name=p8 sig_type=std_logic lab=vin2


}
C {devices/lab_wire.sym} -7950 16350 0 0 {name=p9 sig_type=std_logic lab=vo1

}
C {devices/lab_wire.sym} -7620 16360 0 0 {name=p10 sig_type=std_logic lab=vo2


}
C {devices/lab_wire.sym} -8070 16230 0 0 {name=p20 sig_type=std_logic lab=Vbn




}
C {devices/lab_wire.sym} -7480 16230 0 0 {name=p21 sig_type=std_logic lab=Vbn




}
C {sky130_fd_pr/nfet_01v8.sym} -7970 16420 0 0 {name=M1
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -7600 16420 0 1 {name=M2
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/cap_mim_m3_1.sym} -7790 16330 1 0 {name=C3 model=cap_mim_m3_1 W=20 L=10 MF=1 spiceprefix=X}
C {sky130_fd_pr/nfet_01v8.sym} -8130 16400 0 0 {name=M4
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -7420 16400 0 1 {name=M5
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} -8350 16870 0 0 {name=p11 sig_type=std_logic lab=vo1

}
C {devices/lab_wire.sym} -8040 16860 0 0 {name=p12 sig_type=std_logic lab=vo2


}
C {devices/lab_wire.sym} -8190 16860 0 0 {name=p13 sig_type=std_logic lab=Vcm_det



}
C {devices/lab_wire.sym} -7550 16880 0 0 {name=p14 sig_type=std_logic lab=Vc1+



}
C {devices/lab_wire.sym} -7240 16890 0 1 {name=p15 sig_type=std_logic lab=Vc1+



}
C {devices/lab_wire.sym} -7410 16890 0 1 {name=p17 sig_type=std_logic lab=Vcm




}
C {devices/lab_wire.sym} -7650 16940 0 1 {name=p16 sig_type=std_logic lab=Vcm




}
C {devices/lab_wire.sym} -7950 16940 0 0 {name=p18 sig_type=std_logic lab=Vcm_det



}
C {devices/lab_wire.sym} -7710 16870 0 0 {name=p19 sig_type=std_logic lab=Vbn




}
C {sky130_fd_pr/pfet_01v8.sym} -8310 16930 0 0 {name=M8
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -8080 16930 0 1 {name=M12
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -8310 16790 0 0 {name=M10
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -8080 16790 0 1 {name=M11
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -7870 16800 0 1 {name=M9
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -7730 16800 0 0 {name=M13
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -7910 16940 0 0 {name=M14
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -7690 16940 0 1 {name=M15
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -7820 17050 0 0 {name=M16
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -7510 16820 0 0 {name=M17
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -7280 16820 0 1 {name=M19
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -7510 16960 0 0 {name=M20
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -7280 16960 0 1 {name=M21
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -7980 17060 0 0 {name=M22
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -7640 17050 0 1 {name=M23
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -7910 16700 0 1 {name=M24
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -7740 16700 0 0 {name=M25
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} -8190 16730 0 0 {name=p3 sig_type=std_logic lab=Vdd




}
C {devices/lab_wire.sym} -7880 16670 0 0 {name=p4 sig_type=std_logic lab=Vdd




}
C {devices/lab_wire.sym} -7400 16760 0 0 {name=p5 sig_type=std_logic lab=Vdd




}
C {devices/lab_wire.sym} -8190 16990 0 0 {name=p6 sig_type=std_logic lab=gnd





}
C {devices/lab_wire.sym} -7830 17110 0 0 {name=p22 sig_type=std_logic lab=gnd





}
C {devices/lab_wire.sym} -7400 17020 0 0 {name=p23 sig_type=std_logic lab=gnd





}
C {devices/lab_wire.sym} -7780 16670 0 0 {name=p24 sig_type=std_logic lab=Vdd




}
C {devices/lab_wire.sym} -8170 16930 0 0 {name=p25 sig_type=std_logic lab=Vdd




}
C {devices/lab_wire.sym} -8200 16790 0 0 {name=p26 sig_type=std_logic lab=gnd





}
C {devices/lab_wire.sym} -7370 16960 0 0 {name=p27 sig_type=std_logic lab=Vdd




}
C {devices/lab_wire.sym} -7390 16820 0 0 {name=p28 sig_type=std_logic lab=gnd





}
C {devices/lab_wire.sym} -7800 16940 0 0 {name=p29 sig_type=std_logic lab=gnd





}
C {devices/lab_wire.sym} -7850 17050 0 0 {name=p63 sig_type=std_logic lab=Vbias1

}
C {sky130_fd_pr/pfet_01v8_lvt.sym} -7970 16230 0 0 {name=M18
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} -7980 16130 0 0 {name=M6
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} -7600 16230 0 1 {name=M7
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} -7610 16130 0 1 {name=M49
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {devices/lab_wire.sym} -7800 16420 0 0 {name=p64 sig_type=std_logic lab=gnd

}
C {sky130_fd_pr/nfet_01v8.sym} -7810 16560 0 0 {name=M50
L=0.5
W=6
nf=6 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} -7680 16590 0 0 {name=p65 sig_type=std_logic lab=gnd

}
C {devices/lab_wire.sym} -7860 16560 0 0 {name=p66 sig_type=std_logic lab=Vbias1

}
C {devices/lab_wire.sym} -8120 16470 0 0 {name=p67 sig_type=std_logic lab=gnd

}
C {devices/lab_wire.sym} -7410 16470 0 0 {name=p68 sig_type=std_logic lab=gnd

}
C {sky130_fd_pr/nfet_01v8.sym} -8900 16780 0 0 {name=M3
L=0.15
W=3.36
nf=8 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} -8850 16810 0 1 {name=p1 sig_type=std_logic lab=gnd

}
C {devices/lab_wire.sym} -8760 16720 0 0 {name=p32 sig_type=std_logic lab=Vdd




}
C {sky130_fd_pr/nfet_01v8.sym} -8740 16780 0 0 {name=M51
L=0.15
W=3.36
nf=8 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -8590 16780 0 0 {name=M52
L=0.15
W=4.2
nf=10
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -8450 16780 0 0 {name=M53
L=0.15
W=3.36
nf=8
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} -8960 16910 0 1 {name=p69 sig_type=std_logic lab=gnd

}
C {devices/lab_wire.sym} -8890 17000 0 0 {name=p70 sig_type=std_logic lab=Vdd




}
C {sky130_fd_pr/pfet_01v8.sym} -9020 16970 0 0 {name=M54
L=0.15
W=3.36
nf=8
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -8860 16970 0 0 {name=M55
L=0.15
W=3.36
nf=8
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -8710 16970 0 0 {name=M56
L=0.15
W=3.36
nf=8
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -8570 16970 0 0 {name=M57
L=0.15
W=3.36
nf=8
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -8430 16970 0 0 {name=M58
L=0.15
W=8.4
nf=20
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -9150 16970 0 0 {name=M59
L=0.15
W=3.36
nf=8
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -8870 17160 0 0 {name=M60
L=0.15
W=1.68
nf=4
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} -8820 17190 0 1 {name=p71 sig_type=std_logic lab=gnd

}
C {devices/lab_wire.sym} -8840 17100 0 0 {name=p72 sig_type=std_logic lab=Vbias1

}
C {sky130_fd_pr/nfet_01v8.sym} -8560 17190 0 0 {name=M61
L=0.15
W=1.68
nf=4
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} -8510 17220 0 1 {name=p73 sig_type=std_logic lab=gnd

}
C {devices/lab_wire.sym} -8530 17130 0 0 {name=p74 sig_type=std_logic lab=Vbias1

}
C {sky130_fd_pr/nfet_01v8.sym} -6290 15950 0 0 {name=M62
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -6420 15950 0 0 {name=M63
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -5920 15950 0 1 {name=M64
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -6180 16080 0 0 {name=M65
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -6440 15640 0 0 {name=M66
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -5920 15640 0 1 {name=M67
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -6250 15640 0 1 {name=M68
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -6120 15640 0 0 {name=M69
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -6250 15820 0 1 {name=M70
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -6120 15820 0 0 {name=M71
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -6080 15950 0 1 {name=M72
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -6160 16150 0 0 {name=l3 lab=GND}
C {devices/gnd.sym} -6370 15950 0 0 {name=l1 lab=GND}
C {devices/gnd.sym} -6190 15950 0 0 {name=l2 lab=GND}
C {devices/gnd.sym} -5970 15950 0 0 {name=l4 lab=GND}
C {devices/gnd.sym} -6030 15820 0 0 {name=l5 lab=GND}
C {devices/gnd.sym} -6350 15820 0 0 {name=l6 lab=GND}
C {devices/lab_wire.sym} -6170 15590 0 0 {name=p75 sig_type=std_logic lab=Vdd
}
C {sky130_fd_pr/pfet_01v8.sym} -6200 15900 1 1 {name=M73
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} -6200 15840 1 0 {name=p76 sig_type=std_logic lab=Vdd
}
C {devices/lab_wire.sym} -5870 15950 0 0 {name=p77 sig_type=std_logic lab=Vc+
}
C {devices/lab_wire.sym} -6460 15950 0 0 {name=p78 sig_type=std_logic lab=Vc-
}
C {devices/lab_wire.sym} -6320 15950 0 0 {name=p79 sig_type=std_logic lab=vo1
}
C {devices/lab_wire.sym} -6040 15950 0 0 {name=p80 sig_type=std_logic lab=vo2
}
C {devices/lab_pin.sym} -6235 16080 0 0 {name=p81 sig_type=std_logic lab=clk
}
C {devices/lab_pin.sym} -6155 15920 0 0 {name=p82 sig_type=std_logic lab=clk
}
C {devices/lab_pin.sym} -6495 15640 0 0 {name=p83 sig_type=std_logic lab=clk
}
C {devices/lab_pin.sym} -5865 15640 0 1 {name=p84 sig_type=std_logic lab=clk
}
C {devices/lab_wire.sym} -6270 15750 0 0 {name=p85 sig_type=std_logic lab=Vo+
}
C {devices/lab_wire.sym} -6100 15750 0 0 {name=p86 sig_type=std_logic lab=Vo-
}
C {sky130_fd_pr/pfet_01v8.sym} -5630 15650 0 0 {name=M74
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -5110 15650 0 1 {name=M75
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -5440 15650 0 1 {name=M76
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -5310 15650 0 0 {name=M77
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} -5360 15600 0 0 {name=p87 sig_type=std_logic lab=Vdd
}
C {devices/lab_pin.sym} -5685 15650 0 0 {name=p88 sig_type=std_logic lab=Vo-
}
C {devices/lab_pin.sym} -5055 15650 0 1 {name=p89 sig_type=std_logic lab=Vo+
}
C {sky130_fd_pr/pfet_01v8.sym} -5440 15820 0 1 {name=M78
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -5310 15820 0 0 {name=M79
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -5440 16000 0 1 {name=M80
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -5310 16000 0 0 {name=M81
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -5220 16000 0 0 {name=l13 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} -5480 16110 0 0 {name=M82
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -5630 16110 0 0 {name=M83
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -5110 16110 0 1 {name=M84
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -5270 16110 0 1 {name=M85
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -5580 16110 0 0 {name=l14 lab=GND}
C {devices/gnd.sym} -5380 16110 0 0 {name=l15 lab=GND}
C {devices/gnd.sym} -5160 16110 0 0 {name=l16 lab=GND}
C {devices/lab_wire.sym} -5510 16110 0 0 {name=p90 sig_type=std_logic lab=Vo-
}
C {devices/lab_wire.sym} -5230 16110 0 0 {name=p91 sig_type=std_logic lab=Vo+

}
C {devices/gnd.sym} -5350 16210 0 0 {name=l17 lab=GND}
C {devices/lab_wire.sym} -6100 16260 0 0 {name=p92 sig_type=std_logic lab=Vo+
}
C {devices/lab_wire.sym} -6080 16500 0 0 {name=p93 sig_type=std_logic lab=Vo-
}
C {devices/lab_wire.sym} -5880 16280 0 0 {name=p94 sig_type=std_logic lab=Vo1+
}
C {devices/lab_wire.sym} -5940 16520 0 0 {name=p95 sig_type=std_logic lab=Vo1-
}
C {devices/lab_wire.sym} -5410 15650 0 1 {name=p96 sig_type=std_logic lab=Vo1+
}
C {devices/lab_wire.sym} -5340 15650 0 0 {name=p97 sig_type=std_logic lab=Vo1-
}
C {devices/lab_wire.sym} -5670 16110 0 0 {name=p98 sig_type=std_logic lab=Vo1+
}
C {devices/lab_wire.sym} -5080 16110 0 1 {name=p99 sig_type=std_logic lab=Vo1-
}
C {devices/lab_wire.sym} -5410 15920 0 0 {name=p100 sig_type=std_logic lab=Q1
}
C {devices/lab_wire.sym} -5340 15950 0 0 {name=p101 sig_type=std_logic lab=Q
}
C {devices/gnd.sym} -6000 16370 0 0 {name=l31 lab=GND}
C {devices/lab_wire.sym} -6000 16180 0 0 {name=p102 sig_type=std_logic lab=Vdd
}
C {sky130_fd_pr/pfet_01v8.sym} -6020 16240 0 0 {name=M86
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -6020 16320 0 0 {name=M87
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -6020 16480 0 0 {name=M88
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -6020 16560 0 0 {name=M89
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -6000 16610 0 0 {name=l7 lab=GND}
C {devices/lab_wire.sym} -6000 16430 0 0 {name=p103 sig_type=std_logic lab=Vdd
}
C {sky130_fd_pr/nfet_01v8.sym} -6270 17150 0 0 {name=M90
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -6400 17150 0 0 {name=M91
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -5900 17150 0 1 {name=M92
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -6160 17280 0 0 {name=M93
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -6420 16840 0 0 {name=M94
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -5900 16840 0 1 {name=M95
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -6230 16840 0 1 {name=M96
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -6100 16840 0 0 {name=M97
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -6230 17020 0 1 {name=M98
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -6100 17020 0 0 {name=M99
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -6060 17150 0 1 {name=M100
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -6140 17350 0 0 {name=l8 lab=GND}
C {devices/gnd.sym} -6350 17150 0 0 {name=l9 lab=GND}
C {devices/gnd.sym} -6170 17150 0 0 {name=l10 lab=GND}
C {devices/gnd.sym} -5950 17150 0 0 {name=l11 lab=GND}
C {devices/gnd.sym} -6010 17020 0 0 {name=l12 lab=GND}
C {devices/gnd.sym} -6330 17020 0 0 {name=l18 lab=GND}
C {devices/lab_wire.sym} -6150 16790 0 0 {name=p104 sig_type=std_logic lab=Vdd
}
C {sky130_fd_pr/pfet_01v8.sym} -6180 17100 1 1 {name=M101
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} -6180 17040 1 0 {name=p105 sig_type=std_logic lab=Vdd
}
C {devices/lab_wire.sym} -6300 17150 0 0 {name=p106 sig_type=std_logic lab=vo1
}
C {devices/lab_wire.sym} -6020 17150 0 0 {name=p107 sig_type=std_logic lab=vo2
}
C {devices/lab_pin.sym} -6215 17280 0 0 {name=p108 sig_type=std_logic lab=clk
}
C {devices/lab_pin.sym} -6135 17120 0 0 {name=p109 sig_type=std_logic lab=clk
}
C {devices/lab_pin.sym} -6475 16840 0 0 {name=p110 sig_type=std_logic lab=clk
}
C {devices/lab_pin.sym} -5845 16840 0 1 {name=p111 sig_type=std_logic lab=clk
}
C {devices/lab_wire.sym} -6250 16950 0 0 {name=p112 sig_type=std_logic lab=Vo2+
}
C {devices/lab_wire.sym} -6080 16950 0 0 {name=p113 sig_type=std_logic lab=Vo2-
}
C {sky130_fd_pr/pfet_01v8.sym} -5610 16850 0 0 {name=M102
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -5090 16850 0 1 {name=M103
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -5420 16850 0 1 {name=M104
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -5290 16850 0 0 {name=M105
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} -5340 16800 0 0 {name=p114 sig_type=std_logic lab=Vdd
}
C {devices/lab_pin.sym} -5665 16850 0 0 {name=p115 sig_type=std_logic lab=Vo2-
}
C {devices/lab_pin.sym} -5035 16850 0 1 {name=p116 sig_type=std_logic lab=Vo2+
}
C {sky130_fd_pr/pfet_01v8.sym} -5420 17020 0 1 {name=M106
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -5290 17020 0 0 {name=M107
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -5420 17200 0 1 {name=M108
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -5290 17200 0 0 {name=M109
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -5200 17200 0 0 {name=l19 lab=GND}
C {sky130_fd_pr/nfet_01v8.sym} -5460 17310 0 0 {name=M110
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -5610 17310 0 0 {name=M111
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -5090 17310 0 1 {name=M112
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -5250 17310 0 1 {name=M113
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
lab=Vo2+}
C {devices/gnd.sym} -5560 17310 0 0 {name=l20 lab=GND}
C {devices/gnd.sym} -5360 17310 0 0 {name=l21 lab=GND}
C {devices/gnd.sym} -5140 17310 0 0 {name=l22 lab=GND}
C {devices/lab_wire.sym} -5490 17310 0 0 {name=p117 sig_type=std_logic lab=Vo2-
}
C {devices/lab_wire.sym} -5210 17310 0 0 {name=p118 sig_type=std_logic lab=Vo2+

}
C {devices/gnd.sym} -5330 17410 0 0 {name=l23 lab=GND}
C {devices/lab_wire.sym} -6080 17460 0 0 {name=p119 sig_type=std_logic lab=Vo2+
}
C {devices/lab_wire.sym} -6060 17700 0 0 {name=p120 sig_type=std_logic lab=Vo2-
}
C {devices/lab_wire.sym} -5860 17480 0 0 {name=p121 sig_type=std_logic lab=Vo3+
}
C {devices/lab_wire.sym} -5920 17720 0 0 {name=p122 sig_type=std_logic lab=Vo3-
}
C {devices/lab_wire.sym} -5390 16850 0 1 {name=p123 sig_type=std_logic lab=Vo3+
}
C {devices/lab_wire.sym} -5320 16850 0 0 {name=p124 sig_type=std_logic lab=Vo3-
}
C {devices/lab_wire.sym} -5650 17310 0 0 {name=p125 sig_type=std_logic lab=Vo3+
}
C {devices/lab_wire.sym} -5060 17310 0 1 {name=p126 sig_type=std_logic lab=Vo3-
}
C {devices/lab_wire.sym} -5390 17120 0 0 {name=p127 sig_type=std_logic lab=Q2
}
C {devices/lab_wire.sym} -5320 17150 0 0 {name=p128 sig_type=std_logic lab=Q3
}
C {devices/gnd.sym} -5980 17570 0 0 {name=l24 lab=GND}
C {devices/lab_wire.sym} -5980 17380 0 0 {name=p129 sig_type=std_logic lab=Vdd
}
C {sky130_fd_pr/pfet_01v8.sym} -6000 17440 0 0 {name=M114
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -6000 17520 0 0 {name=M115
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} -6000 17680 0 0 {name=M116
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -6000 17760 0 0 {name=M117
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -5980 17810 0 0 {name=l25 lab=GND}
C {devices/lab_wire.sym} -5980 17630 0 0 {name=p130 sig_type=std_logic lab=Vdd
}
C {devices/lab_wire.sym} -5860 17150 0 0 {name=p131 sig_type=std_logic lab=Vc-
}
C {devices/lab_wire.sym} -6450 17150 0 0 {name=p132 sig_type=std_logic lab=Vc+
}
C {sky130_stdcells/xnor2_4.sym} -4680 16360 0 0 {name=x1 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {devices/lab_pin.sym} -6770 16110 1 0 {name=p133 sig_type=std_logic lab=vdd}
C {sky130_fd_pr/pfet_01v8_lvt.sym} -6800 16180 0 0 {name=M118
L=4
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} -6800 16290 0 0 {name=M119
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} -6800 16390 0 0 {name=M120
L=4
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {devices/lab_pin.sym} -6780 16450 2 0 {name=p134 sig_type=std_logic lab=gnd}
C {devices/lab_wire.sym} -6710 16350 0 0 {name=p135 sig_type=std_logic lab=Vc-
}
C {devices/lab_wire.sym} -6720 16250 0 0 {name=p136 sig_type=std_logic lab=Vc+
}
C {sky130_fd_pr/nfet_01v8.sym} -6790 16990 0 0 {name=M121
L=0.15
W=20.16
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} -6830 16990 0 0 {name=p137 sig_type=std_logic lab=Vdd
}
C {devices/gnd.sym} -6730 17050 0 0 {name=l26 lab=GND}
C {/home/ganga/Desktop/xschemfiles/scanchain.sym} -4020 16000 0 0 {name=x2}
C {devices/gnd.sym} -4030 16350 0 0 {name=l27 lab=GND}
C {devices/lab_wire.sym} -4030 16060 0 0 {name=p138 sig_type=std_logic lab=Vdd
}
C {devices/lab_pin.sym} -4240 16200 2 1 {name=p139 sig_type=std_logic lab=reset
}
C {devices/lab_pin.sym} -4240 16220 2 1 {name=p140 sig_type=std_logic lab=scan_en
}
C {devices/lab_pin.sym} -4220 16240 2 1 {name=p141 sig_type=std_logic lab=scan_in
}
C {devices/lab_pin.sym} -4200 16110 2 1 {name=p142 sig_type=std_logic lab=clk
}
C {devices/code_shown.sym} -7565 17560 0 0 {name=s1 only_toplevel=false value="
.include /home/ganga/Desktop/charge_pumps/scanchain.spice
.include /home/ganga/sky_pdk/sky130/sky130A/libs.ref/sky130_fd_sc_hd/spice/sky130_fd_sc_hd.spice
"}
C {CP1_test.sym} -3600 15490 0 0 {name=x3}
C {devices/lab_pin.sym} -3600 15370 1 0 {name=p143 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -3750 15400 0 0 {name=p145 sig_type=std_logic lab=in1
value=0}
C {devices/lab_pin.sym} -3750 15420 0 0 {name=p146 sig_type=std_logic lab=in2
value=0}
C {devices/lab_pin.sym} -3750 15440 0 0 {name=p147 sig_type=std_logic lab=in3
value=0}
C {devices/lab_pin.sym} -3750 15460 0 0 {name=p148 sig_type=std_logic lab=in4
value=0}
C {devices/lab_pin.sym} -3750 15480 0 0 {name=p149 sig_type=std_logic lab=in5
value=0}
C {devices/lab_pin.sym} -3750 15500 0 0 {name=p150 sig_type=std_logic lab=in6
value=0}
C {devices/lab_pin.sym} -3750 15520 0 0 {name=p151 sig_type=std_logic lab=in7
value=0}
C {devices/lab_pin.sym} -3750 15540 0 0 {name=p152 sig_type=std_logic lab=in8
value=0}
C {devices/lab_pin.sym} -3750 15580 0 0 {name=p153 sig_type=std_logic lab=vin+}
C {devices/lab_pin.sym} -3600 15610 3 0 {name=p190 sig_type=std_logic lab=gnd}
C {CP1_test.sym} -2900 15520 0 0 {name=x4}
C {devices/lab_pin.sym} -2900 15400 1 0 {name=p157 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -3050 15430 0 0 {name=p158 sig_type=std_logic lab=in1
value=0}
C {devices/lab_pin.sym} -3050 15450 0 0 {name=p159 sig_type=std_logic lab=in2
value=0}
C {devices/lab_pin.sym} -3050 15470 0 0 {name=p160 sig_type=std_logic lab=in3
value=0}
C {devices/lab_pin.sym} -3050 15490 0 0 {name=p161 sig_type=std_logic lab=in4
value=0}
C {devices/lab_pin.sym} -3050 15510 0 0 {name=p162 sig_type=std_logic lab=in5
value=0}
C {devices/lab_pin.sym} -3050 15530 0 0 {name=p163 sig_type=std_logic lab=in6
value=0}
C {devices/lab_pin.sym} -3050 15550 0 0 {name=p164 sig_type=std_logic lab=in7
value=0}
C {devices/lab_pin.sym} -3050 15570 0 0 {name=p165 sig_type=std_logic lab=in8
value=0}
C {devices/lab_pin.sym} -2900 15640 3 0 {name=p166 sig_type=std_logic lab=gnd}
C {CP1_test.sym} -2210 15520 0 0 {name=x7}
C {devices/lab_pin.sym} -2210 15400 1 0 {name=p172 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -2360 15430 0 0 {name=p173 sig_type=std_logic lab=in1
value=0}
C {devices/lab_pin.sym} -2360 15450 0 0 {name=p174 sig_type=std_logic lab=in2
value=0}
C {devices/lab_pin.sym} -2360 15470 0 0 {name=p175 sig_type=std_logic lab=in3
value=0}
C {devices/lab_pin.sym} -2360 15490 0 0 {name=p176 sig_type=std_logic lab=in4
value=0}
C {devices/lab_pin.sym} -2360 15510 0 0 {name=p177 sig_type=std_logic lab=in5
value=0}
C {devices/lab_pin.sym} -2360 15530 0 0 {name=p178 sig_type=std_logic lab=in6
value=0}
C {devices/lab_pin.sym} -2360 15550 0 0 {name=p179 sig_type=std_logic lab=in7
value=0}
C {devices/lab_pin.sym} -2360 15570 0 0 {name=p180 sig_type=std_logic lab=in8
value=0}
C {devices/lab_pin.sym} -2210 15640 3 0 {name=p181 sig_type=std_logic lab=gnd}
C {CP1_test.sym} -1560 15520 0 0 {name=x10}
C {devices/lab_pin.sym} -1560 15400 1 0 {name=p186 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -1710 15430 0 0 {name=p187 sig_type=std_logic lab=in1
value=0}
C {devices/lab_pin.sym} -1710 15450 0 0 {name=p188 sig_type=std_logic lab=in2
value=0}
C {devices/lab_pin.sym} -1710 15470 0 0 {name=p189 sig_type=std_logic lab=in3
value=0}
C {devices/lab_pin.sym} -1710 15490 0 0 {name=p191 sig_type=std_logic lab=in4
value=0}
C {devices/lab_pin.sym} -1710 15510 0 0 {name=p192 sig_type=std_logic lab=in5
value=0}
C {devices/lab_pin.sym} -1710 15530 0 0 {name=p193 sig_type=std_logic lab=in6
value=0}
C {devices/lab_pin.sym} -1710 15550 0 0 {name=p194 sig_type=std_logic lab=in7
value=0}
C {devices/lab_pin.sym} -1710 15570 0 0 {name=p195 sig_type=std_logic lab=in8
value=0}
C {devices/lab_pin.sym} -1560 15640 3 0 {name=p196 sig_type=std_logic lab=gnd}
C {CP1_test.sym} -800 15510 0 0 {name=x13}
C {devices/lab_pin.sym} -800 15390 1 0 {name=p201 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -950 15420 0 0 {name=p202 sig_type=std_logic lab=in1
value=0}
C {devices/lab_pin.sym} -950 15440 0 0 {name=p203 sig_type=std_logic lab=in2
value=0}
C {devices/lab_pin.sym} -950 15460 0 0 {name=p204 sig_type=std_logic lab=in3
value=0}
C {devices/lab_pin.sym} -950 15480 0 0 {name=p205 sig_type=std_logic lab=in4
value=0}
C {devices/lab_pin.sym} -950 15500 0 0 {name=p206 sig_type=std_logic lab=in5
value=0}
C {devices/lab_pin.sym} -950 15520 0 0 {name=p207 sig_type=std_logic lab=in6
value=0}
C {devices/lab_pin.sym} -950 15540 0 0 {name=p208 sig_type=std_logic lab=in7
value=0}
C {devices/lab_pin.sym} -950 15560 0 0 {name=p209 sig_type=std_logic lab=in8
value=0}
C {devices/lab_pin.sym} -800 15630 3 0 {name=p210 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} 50 16500 3 1 {name=p216 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 110 16160 3 1 {name=p217 sig_type=std_logic lab=clk_in}
C {devices/lab_pin.sym} 200 16530 0 1 {name=p218 sig_type=std_logic lab=in1
value=0}
C {devices/lab_pin.sym} 200 16550 0 1 {name=p219 sig_type=std_logic lab=in2
value=0}
C {devices/lab_pin.sym} 200 16570 0 1 {name=p220 sig_type=std_logic lab=in3
value=0}
C {devices/lab_pin.sym} 200 16590 0 1 {name=p221 sig_type=std_logic lab=in4
value=0}
C {devices/lab_pin.sym} 200 16610 0 1 {name=p222 sig_type=std_logic lab=in5
value=0}
C {devices/lab_pin.sym} 200 16630 0 1 {name=p223 sig_type=std_logic lab=in6
value=0}
C {devices/lab_pin.sym} 200 16650 0 1 {name=p224 sig_type=std_logic lab=in7
value=0}
C {devices/lab_pin.sym} 200 16670 0 1 {name=p225 sig_type=std_logic lab=in8
value=0}
C {devices/lab_pin.sym} 50 16760 1 1 {name=p227 sig_type=std_logic lab=gnd}
C {buffer_digital.sym} -60 16120 0 1 {name=x17}
C {buffer_digital.sym} -100 16330 0 1 {name=x18}
C {devices/lab_pin.sym} -50 16070 3 1 {name=p228 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -90 16280 3 1 {name=p229 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -80 16170 1 1 {name=p230 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -120 16380 1 1 {name=p231 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -650 16530 3 1 {name=p232 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -500 16560 0 1 {name=p233 sig_type=std_logic lab=in1
value=0}
C {devices/lab_pin.sym} -500 16580 0 1 {name=p234 sig_type=std_logic lab=in2
value=0}
C {devices/lab_pin.sym} -500 16600 0 1 {name=p235 sig_type=std_logic lab=in3
value=0}
C {devices/lab_pin.sym} -500 16620 0 1 {name=p236 sig_type=std_logic lab=in4
value=0}
C {devices/lab_pin.sym} -500 16640 0 1 {name=p237 sig_type=std_logic lab=in5
value=0}
C {devices/lab_pin.sym} -500 16660 0 1 {name=p238 sig_type=std_logic lab=in6
value=0}
C {devices/lab_pin.sym} -500 16680 0 1 {name=p239 sig_type=std_logic lab=in7
value=0}
C {devices/lab_pin.sym} -500 16700 0 1 {name=p240 sig_type=std_logic lab=in8
value=0}
C {devices/lab_pin.sym} -650 16790 1 1 {name=p241 sig_type=std_logic lab=gnd}
C {buffer_digital.sym} -760 16150 0 1 {name=x19}
C {buffer_digital.sym} -800 16360 0 1 {name=x21}
C {devices/lab_pin.sym} -750 16100 3 1 {name=p242 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -790 16310 3 1 {name=p243 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -780 16200 1 1 {name=p244 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -820 16410 1 1 {name=p245 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -1340 16530 3 1 {name=p246 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -1190 16560 0 1 {name=p247 sig_type=std_logic lab=in1
value=0}
C {devices/lab_pin.sym} -1190 16580 0 1 {name=p248 sig_type=std_logic lab=in2
value=0}
C {devices/lab_pin.sym} -1190 16600 0 1 {name=p249 sig_type=std_logic lab=in3
value=0}
C {devices/lab_pin.sym} -1190 16620 0 1 {name=p250 sig_type=std_logic lab=in4
value=0}
C {devices/lab_pin.sym} -1190 16640 0 1 {name=p251 sig_type=std_logic lab=in5
value=0}
C {devices/lab_pin.sym} -1190 16660 0 1 {name=p252 sig_type=std_logic lab=in6
value=0}
C {devices/lab_pin.sym} -1190 16680 0 1 {name=p253 sig_type=std_logic lab=in7
value=0}
C {devices/lab_pin.sym} -1190 16700 0 1 {name=p254 sig_type=std_logic lab=in8
value=0}
C {devices/lab_pin.sym} -1340 16790 1 1 {name=p255 sig_type=std_logic lab=gnd}
C {buffer_digital.sym} -1450 16150 0 1 {name=x22}
C {buffer_digital.sym} -1490 16360 0 1 {name=x23}
C {devices/lab_pin.sym} -1440 16100 3 1 {name=p256 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -1480 16310 3 1 {name=p257 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -1470 16200 1 1 {name=p258 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -1510 16410 1 1 {name=p259 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -1990 16530 3 1 {name=p260 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -1840 16560 0 1 {name=p261 sig_type=std_logic lab=in1
value=0}
C {devices/lab_pin.sym} -1840 16580 0 1 {name=p262 sig_type=std_logic lab=in2
value=0}
C {devices/lab_pin.sym} -1840 16600 0 1 {name=p263 sig_type=std_logic lab=in3
value=0}
C {devices/lab_pin.sym} -1840 16620 0 1 {name=p264 sig_type=std_logic lab=in4
value=0}
C {devices/lab_pin.sym} -1840 16640 0 1 {name=p265 sig_type=std_logic lab=in5
value=0}
C {devices/lab_pin.sym} -1840 16660 0 1 {name=p266 sig_type=std_logic lab=in6
value=0}
C {devices/lab_pin.sym} -1840 16680 0 1 {name=p267 sig_type=std_logic lab=in7
value=0}
C {devices/lab_pin.sym} -1840 16700 0 1 {name=p268 sig_type=std_logic lab=in8
value=0}
C {devices/lab_pin.sym} -1990 16790 1 1 {name=p269 sig_type=std_logic lab=gnd}
C {buffer_digital.sym} -2100 16150 0 1 {name=x24}
C {buffer_digital.sym} -2140 16360 0 1 {name=x25}
C {devices/lab_pin.sym} -2090 16100 3 1 {name=p270 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -2130 16310 3 1 {name=p271 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -2120 16200 1 1 {name=p272 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -2160 16410 1 1 {name=p273 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -2750 16520 3 1 {name=p274 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -2600 16550 0 1 {name=p275 sig_type=std_logic lab=in1
value=0}
C {devices/lab_pin.sym} -2600 16570 0 1 {name=p276 sig_type=std_logic lab=in2
value=0}
C {devices/lab_pin.sym} -2600 16590 0 1 {name=p277 sig_type=std_logic lab=in3
value=0}
C {devices/lab_pin.sym} -2600 16610 0 1 {name=p278 sig_type=std_logic lab=in4
value=0}
C {devices/lab_pin.sym} -2600 16630 0 1 {name=p279 sig_type=std_logic lab=in5
value=0}
C {devices/lab_pin.sym} -2600 16650 0 1 {name=p280 sig_type=std_logic lab=in6
value=0}
C {devices/lab_pin.sym} -2600 16670 0 1 {name=p281 sig_type=std_logic lab=in7
value=0}
C {devices/lab_pin.sym} -2600 16690 0 1 {name=p282 sig_type=std_logic lab=in8
value=0}
C {devices/lab_pin.sym} -2750 16780 1 1 {name=p283 sig_type=std_logic lab=gnd}
C {buffer_digital.sym} -2860 16140 0 1 {name=x26}
C {buffer_digital.sym} -2900 16350 0 1 {name=x27}
C {devices/lab_pin.sym} -2850 16090 3 1 {name=p284 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -2890 16300 3 1 {name=p285 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -2880 16190 1 1 {name=p286 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -2920 16400 1 1 {name=p287 sig_type=std_logic lab=gnd}
C {CP2_test.sym} 50 16630 0 1 {name=x28}
C {CP2_test.sym} -650 16660 0 1 {name=x29}
C {CP2_test.sym} -1990 16660 0 1 {name=x30}
C {CP2_test.sym} -1340 16660 0 1 {name=x31}
C {CP2_test.sym} -2750 16650 0 1 {name=x32}
C {devices/lab_pin.sym} -3230 17480 1 0 {name=p215 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -3290 17140 1 0 {name=p288 sig_type=std_logic lab=clk_in}
C {devices/lab_pin.sym} -3380 17510 0 0 {name=p290 sig_type=std_logic lab=in1
value=0}
C {devices/lab_pin.sym} -3380 17530 0 0 {name=p291 sig_type=std_logic lab=in2
value=0}
C {devices/lab_pin.sym} -3380 17550 0 0 {name=p292 sig_type=std_logic lab=in3
value=0}
C {devices/lab_pin.sym} -3380 17570 0 0 {name=p293 sig_type=std_logic lab=in4
value=0}
C {devices/lab_pin.sym} -3380 17590 0 0 {name=p294 sig_type=std_logic lab=in5
value=0}
C {devices/lab_pin.sym} -3380 17610 0 0 {name=p295 sig_type=std_logic lab=in6
value=0}
C {devices/lab_pin.sym} -3380 17630 0 0 {name=p296 sig_type=std_logic lab=in7
value=0}
C {devices/lab_pin.sym} -3380 17650 0 0 {name=p297 sig_type=std_logic lab=in8
value=0}
C {devices/lab_pin.sym} -3230 17740 3 0 {name=p299 sig_type=std_logic lab=gnd}
C {buffer_digital.sym} -3120 17100 0 0 {name=x33}
C {buffer_digital.sym} -3080 17310 0 0 {name=x34}
C {devices/lab_pin.sym} -3130 17050 1 0 {name=p300 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -3090 17260 1 0 {name=p301 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -3100 17150 3 0 {name=p302 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -3060 17360 3 0 {name=p303 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -2530 17510 1 0 {name=p304 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -2680 17540 0 0 {name=p305 sig_type=std_logic lab=in1
value=0}
C {devices/lab_pin.sym} -2680 17560 0 0 {name=p306 sig_type=std_logic lab=in2
value=0}
C {devices/lab_pin.sym} -2680 17580 0 0 {name=p307 sig_type=std_logic lab=in3
value=0}
C {devices/lab_pin.sym} -2680 17600 0 0 {name=p308 sig_type=std_logic lab=in4
value=0}
C {devices/lab_pin.sym} -2680 17620 0 0 {name=p309 sig_type=std_logic lab=in5
value=0}
C {devices/lab_pin.sym} -2680 17640 0 0 {name=p310 sig_type=std_logic lab=in6
value=0}
C {devices/lab_pin.sym} -2680 17660 0 0 {name=p311 sig_type=std_logic lab=in7
value=0}
C {devices/lab_pin.sym} -2680 17680 0 0 {name=p312 sig_type=std_logic lab=in8
value=0}
C {devices/lab_pin.sym} -2530 17770 3 0 {name=p313 sig_type=std_logic lab=gnd}
C {buffer_digital.sym} -2420 17130 0 0 {name=x35}
C {buffer_digital.sym} -2380 17340 0 0 {name=x36}
C {devices/lab_pin.sym} -2430 17080 1 0 {name=p314 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -2390 17290 1 0 {name=p315 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -2400 17180 3 0 {name=p316 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -2360 17390 3 0 {name=p317 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -1840 17510 1 0 {name=p318 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -1990 17540 0 0 {name=p319 sig_type=std_logic lab=in1
value=0}
C {devices/lab_pin.sym} -1990 17560 0 0 {name=p320 sig_type=std_logic lab=in2
value=0}
C {devices/lab_pin.sym} -1990 17580 0 0 {name=p321 sig_type=std_logic lab=in3
value=0}
C {devices/lab_pin.sym} -1990 17600 0 0 {name=p322 sig_type=std_logic lab=in4
value=0}
C {devices/lab_pin.sym} -1990 17620 0 0 {name=p323 sig_type=std_logic lab=in5
value=0}
C {devices/lab_pin.sym} -1990 17640 0 0 {name=p324 sig_type=std_logic lab=in6
value=0}
C {devices/lab_pin.sym} -1990 17660 0 0 {name=p325 sig_type=std_logic lab=in7
value=0}
C {devices/lab_pin.sym} -1990 17680 0 0 {name=p326 sig_type=std_logic lab=in8
value=0}
C {devices/lab_pin.sym} -1840 17770 3 0 {name=p327 sig_type=std_logic lab=gnd}
C {buffer_digital.sym} -1730 17130 0 0 {name=x37}
C {buffer_digital.sym} -1690 17340 0 0 {name=x38}
C {devices/lab_pin.sym} -1740 17080 1 0 {name=p328 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -1700 17290 1 0 {name=p329 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -1710 17180 3 0 {name=p330 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -1670 17390 3 0 {name=p331 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -1190 17510 1 0 {name=p332 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -1340 17540 0 0 {name=p333 sig_type=std_logic lab=in1
value=0}
C {devices/lab_pin.sym} -1340 17560 0 0 {name=p334 sig_type=std_logic lab=in2
value=0}
C {devices/lab_pin.sym} -1340 17580 0 0 {name=p335 sig_type=std_logic lab=in3
value=0}
C {devices/lab_pin.sym} -1340 17600 0 0 {name=p336 sig_type=std_logic lab=in4
value=0}
C {devices/lab_pin.sym} -1340 17620 0 0 {name=p337 sig_type=std_logic lab=in5
value=0}
C {devices/lab_pin.sym} -1340 17640 0 0 {name=p338 sig_type=std_logic lab=in6
value=0}
C {devices/lab_pin.sym} -1340 17660 0 0 {name=p339 sig_type=std_logic lab=in7
value=0}
C {devices/lab_pin.sym} -1340 17680 0 0 {name=p340 sig_type=std_logic lab=in8
value=0}
C {devices/lab_pin.sym} -1190 17770 3 0 {name=p341 sig_type=std_logic lab=gnd}
C {buffer_digital.sym} -1080 17130 0 0 {name=x39}
C {buffer_digital.sym} -1040 17340 0 0 {name=x40}
C {devices/lab_pin.sym} -1090 17080 1 0 {name=p342 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -1050 17290 1 0 {name=p343 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -1060 17180 3 0 {name=p344 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -1020 17390 3 0 {name=p345 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -430 17500 1 0 {name=p346 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -580 17530 0 0 {name=p347 sig_type=std_logic lab=in1
value=0}
C {devices/lab_pin.sym} -580 17550 0 0 {name=p348 sig_type=std_logic lab=in2
value=0}
C {devices/lab_pin.sym} -580 17570 0 0 {name=p349 sig_type=std_logic lab=in3
value=0}
C {devices/lab_pin.sym} -580 17590 0 0 {name=p350 sig_type=std_logic lab=in4
value=0}
C {devices/lab_pin.sym} -580 17610 0 0 {name=p351 sig_type=std_logic lab=in5
value=0}
C {devices/lab_pin.sym} -580 17630 0 0 {name=p352 sig_type=std_logic lab=in6
value=0}
C {devices/lab_pin.sym} -580 17650 0 0 {name=p353 sig_type=std_logic lab=in7
value=0}
C {devices/lab_pin.sym} -580 17670 0 0 {name=p354 sig_type=std_logic lab=in8
value=0}
C {devices/lab_pin.sym} -430 17760 3 0 {name=p355 sig_type=std_logic lab=gnd}
C {buffer_digital.sym} -320 17120 0 0 {name=x41}
C {buffer_digital.sym} -280 17330 0 0 {name=x42}
C {devices/lab_pin.sym} -330 17070 1 0 {name=p356 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -290 17280 1 0 {name=p357 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -300 17170 3 0 {name=p358 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -260 17380 3 0 {name=p359 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -240 17630 2 0 {name=p361 sig_type=std_logic lab=out1}
C {CP2_test.sym} -3230 17610 0 0 {name=x43}
C {CP2_test.sym} -2530 17640 0 0 {name=x44}
C {CP2_test.sym} -1190 17640 0 0 {name=x45}
C {CP2_test.sym} -1840 17640 0 0 {name=x46}
C {CP2_test.sym} -430 17630 0 0 {name=x47}
C {sky130_stdcells/inv_1.sym} -4640 16840 3 1 {name=x48 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {/home/ganga/Desktop/xschemfiles/scanchain.sym} -4100 16760 0 0 {name=x49}
C {devices/gnd.sym} -4110 17110 0 0 {name=l28 lab=GND}
C {devices/lab_wire.sym} -4110 16820 0 0 {name=p226 sig_type=std_logic lab=Vdd
}
C {devices/lab_pin.sym} -4320 16960 2 1 {name=p289 sig_type=std_logic lab=reset
}
C {devices/lab_pin.sym} -4320 16980 2 1 {name=p298 sig_type=std_logic lab=scan_en
}
C {devices/lab_pin.sym} -4300 17000 2 1 {name=p360 sig_type=std_logic lab=scan_in
}
C {devices/lab_pin.sym} -4280 16870 2 1 {name=p362 sig_type=std_logic lab=clk
}
C {devices/lab_pin.sym} -3880 16150 0 1 {name=p363 sig_type=std_logic lab=in1
value=0}
C {devices/lab_pin.sym} -3880 16170 0 1 {name=p364 sig_type=std_logic lab=in2
value=0}
C {devices/lab_pin.sym} -3880 16190 0 1 {name=p365 sig_type=std_logic lab=in3
value=0}
C {devices/lab_pin.sym} -3880 16210 0 1 {name=p366 sig_type=std_logic lab=in4
value=0}
C {devices/lab_pin.sym} -3880 16230 0 1 {name=p367 sig_type=std_logic lab=in5
value=0}
C {devices/lab_pin.sym} -3880 16250 0 1 {name=p368 sig_type=std_logic lab=in6
value=0}
C {devices/lab_pin.sym} -3880 16270 0 1 {name=p369 sig_type=std_logic lab=in7
value=0}
C {devices/lab_pin.sym} -3880 16290 0 1 {name=p370 sig_type=std_logic lab=in8
value=0}
C {CP1_test.sym} -3550 18780 0 0 {name=x50}
C {devices/lab_pin.sym} -3550 18660 1 0 {name=p371 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -3610 18320 1 0 {name=p372 sig_type=std_logic lab=clk_in}
C {devices/lab_pin.sym} -3700 18690 0 0 {name=p373 sig_type=std_logic lab=oin1
value=0}
C {devices/lab_pin.sym} -3700 18710 0 0 {name=p374 sig_type=std_logic lab=oin2
value=0}
C {devices/lab_pin.sym} -3700 18730 0 0 {name=p375 sig_type=std_logic lab=oin3
value=0}
C {devices/lab_pin.sym} -3700 18750 0 0 {name=p376 sig_type=std_logic lab=oin4
value=0}
C {devices/lab_pin.sym} -3700 18770 0 0 {name=p377 sig_type=std_logic lab=oin5
value=0}
C {devices/lab_pin.sym} -3700 18790 0 0 {name=p378 sig_type=std_logic lab=oin6
value=0}
C {devices/lab_pin.sym} -3700 18810 0 0 {name=p379 sig_type=std_logic lab=oin7
value=0}
C {devices/lab_pin.sym} -3700 18830 0 0 {name=p380 sig_type=std_logic lab=oin8
value=0}
C {devices/lab_pin.sym} -3700 18870 0 0 {name=p381 sig_type=std_logic lab=vin-}
C {devices/lab_pin.sym} -3550 18900 3 0 {name=p382 sig_type=std_logic lab=gnd}
C {buffer_digital.sym} -3440 18280 0 0 {name=x51}
C {buffer_digital.sym} -3400 18490 0 0 {name=x52}
C {devices/lab_pin.sym} -3450 18230 1 0 {name=p383 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -3410 18440 1 0 {name=p384 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -3420 18330 3 0 {name=p385 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -3380 18540 3 0 {name=p386 sig_type=std_logic lab=gnd}
C {CP1_test.sym} -2850 18810 0 0 {name=x53}
C {devices/lab_pin.sym} -2850 18690 1 0 {name=p387 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -2850 18930 3 0 {name=p396 sig_type=std_logic lab=gnd}
C {buffer_digital.sym} -2740 18310 0 0 {name=x54}
C {buffer_digital.sym} -2700 18520 0 0 {name=x55}
C {devices/lab_pin.sym} -2750 18260 1 0 {name=p397 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -2710 18470 1 0 {name=p398 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -2720 18360 3 0 {name=p399 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -2680 18570 3 0 {name=p400 sig_type=std_logic lab=gnd}
C {CP1_test.sym} -2160 18810 0 0 {name=x56}
C {devices/lab_pin.sym} -2160 18690 1 0 {name=p401 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -2160 18930 3 0 {name=p410 sig_type=std_logic lab=gnd}
C {buffer_digital.sym} -2050 18310 0 0 {name=x57}
C {buffer_digital.sym} -2010 18520 0 0 {name=x58}
C {devices/lab_pin.sym} -2060 18260 1 0 {name=p411 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -2020 18470 1 0 {name=p412 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -2030 18360 3 0 {name=p413 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -1990 18570 3 0 {name=p414 sig_type=std_logic lab=gnd}
C {CP1_test.sym} -1510 18810 0 0 {name=x59}
C {devices/lab_pin.sym} -1510 18690 1 0 {name=p415 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -1510 18930 3 0 {name=p424 sig_type=std_logic lab=gnd}
C {buffer_digital.sym} -1400 18310 0 0 {name=x60}
C {buffer_digital.sym} -1360 18520 0 0 {name=x61}
C {devices/lab_pin.sym} -1410 18260 1 0 {name=p425 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -1370 18470 1 0 {name=p426 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -1380 18360 3 0 {name=p427 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -1340 18570 3 0 {name=p428 sig_type=std_logic lab=gnd}
C {CP1_test.sym} -750 18800 0 0 {name=x62}
C {devices/lab_pin.sym} -750 18680 1 0 {name=p429 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -750 18920 3 0 {name=p438 sig_type=std_logic lab=gnd}
C {buffer_digital.sym} -640 18300 0 0 {name=x63}
C {buffer_digital.sym} -600 18510 0 0 {name=x64}
C {devices/lab_pin.sym} -650 18250 1 0 {name=p439 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -610 18460 1 0 {name=p440 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -620 18350 3 0 {name=p441 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -580 18560 3 0 {name=p442 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} 100 19790 3 1 {name=p443 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 160 19450 3 1 {name=p444 sig_type=std_logic lab=clk_in}
C {devices/lab_pin.sym} 100 20050 1 1 {name=p453 sig_type=std_logic lab=gnd}
C {buffer_digital.sym} -10 19410 0 1 {name=x65}
C {buffer_digital.sym} -50 19620 0 1 {name=x66}
C {devices/lab_pin.sym} 0 19360 3 1 {name=p454 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -40 19570 3 1 {name=p455 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -30 19460 1 1 {name=p456 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -70 19670 1 1 {name=p457 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -600 19820 3 1 {name=p458 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -600 20080 1 1 {name=p467 sig_type=std_logic lab=gnd}
C {buffer_digital.sym} -710 19440 0 1 {name=x67}
C {buffer_digital.sym} -750 19650 0 1 {name=x68}
C {devices/lab_pin.sym} -700 19390 3 1 {name=p468 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -740 19600 3 1 {name=p469 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -730 19490 1 1 {name=p470 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -770 19700 1 1 {name=p471 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -1290 19820 3 1 {name=p472 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -1290 20080 1 1 {name=p481 sig_type=std_logic lab=gnd}
C {buffer_digital.sym} -1400 19440 0 1 {name=x69}
C {buffer_digital.sym} -1440 19650 0 1 {name=x70}
C {devices/lab_pin.sym} -1390 19390 3 1 {name=p482 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -1430 19600 3 1 {name=p483 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -1420 19490 1 1 {name=p484 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -1460 19700 1 1 {name=p485 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -1940 19820 3 1 {name=p486 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -1940 20080 1 1 {name=p495 sig_type=std_logic lab=gnd}
C {buffer_digital.sym} -2050 19440 0 1 {name=x71}
C {buffer_digital.sym} -2090 19650 0 1 {name=x72}
C {devices/lab_pin.sym} -2040 19390 3 1 {name=p496 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -2080 19600 3 1 {name=p497 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -2070 19490 1 1 {name=p498 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -2110 19700 1 1 {name=p499 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -2700 19810 3 1 {name=p500 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -2700 20070 1 1 {name=p509 sig_type=std_logic lab=gnd}
C {buffer_digital.sym} -2810 19430 0 1 {name=x73}
C {buffer_digital.sym} -2850 19640 0 1 {name=x74}
C {devices/lab_pin.sym} -2800 19380 3 1 {name=p510 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -2840 19590 3 1 {name=p511 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -2830 19480 1 1 {name=p512 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -2870 19690 1 1 {name=p513 sig_type=std_logic lab=gnd}
C {CP2_test.sym} 100 19920 0 1 {name=x75}
C {CP2_test.sym} -600 19950 0 1 {name=x76}
C {CP2_test.sym} -1940 19950 0 1 {name=x77}
C {CP2_test.sym} -1290 19950 0 1 {name=x78}
C {CP2_test.sym} -2700 19940 0 1 {name=x79}
C {devices/lab_pin.sym} -3180 20770 1 0 {name=p514 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -3240 20430 1 0 {name=p515 sig_type=std_logic lab=clk_in}
C {devices/lab_pin.sym} -3180 21030 3 0 {name=p524 sig_type=std_logic lab=gnd}
C {buffer_digital.sym} -3070 20390 0 0 {name=x80}
C {buffer_digital.sym} -3030 20600 0 0 {name=x81}
C {devices/lab_pin.sym} -3080 20340 1 0 {name=p525 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -3040 20550 1 0 {name=p526 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -3050 20440 3 0 {name=p527 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -3010 20650 3 0 {name=p528 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -2480 20800 1 0 {name=p529 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -2480 21060 3 0 {name=p538 sig_type=std_logic lab=gnd}
C {buffer_digital.sym} -2370 20420 0 0 {name=x82}
C {buffer_digital.sym} -2330 20630 0 0 {name=x83}
C {devices/lab_pin.sym} -2380 20370 1 0 {name=p539 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -2340 20580 1 0 {name=p540 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -2350 20470 3 0 {name=p541 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -2310 20680 3 0 {name=p542 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -1790 20800 1 0 {name=p543 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -1790 21060 3 0 {name=p552 sig_type=std_logic lab=gnd}
C {buffer_digital.sym} -1680 20420 0 0 {name=x84}
C {buffer_digital.sym} -1640 20630 0 0 {name=x85}
C {devices/lab_pin.sym} -1690 20370 1 0 {name=p553 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -1650 20580 1 0 {name=p554 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -1660 20470 3 0 {name=p555 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -1620 20680 3 0 {name=p556 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -1140 20800 1 0 {name=p557 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -1140 21060 3 0 {name=p566 sig_type=std_logic lab=gnd}
C {buffer_digital.sym} -1030 20420 0 0 {name=x86}
C {buffer_digital.sym} -990 20630 0 0 {name=x87}
C {devices/lab_pin.sym} -1040 20370 1 0 {name=p567 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -1000 20580 1 0 {name=p568 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -1010 20470 3 0 {name=p569 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -970 20680 3 0 {name=p570 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -380 20790 1 0 {name=p571 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -380 21050 3 0 {name=p580 sig_type=std_logic lab=gnd}
C {buffer_digital.sym} -270 20410 0 0 {name=x88}
C {buffer_digital.sym} -230 20620 0 0 {name=x89}
C {devices/lab_pin.sym} -280 20360 1 0 {name=p581 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -240 20570 1 0 {name=p582 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -250 20460 3 0 {name=p583 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -210 20670 3 0 {name=p584 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -190 20920 2 0 {name=p585 sig_type=std_logic lab=out2}
C {CP2_test.sym} -3180 20900 0 0 {name=x90}
C {CP2_test.sym} -2480 20930 0 0 {name=x91}
C {CP2_test.sym} -1140 20930 0 0 {name=x92}
C {CP2_test.sym} -1790 20930 0 0 {name=x93}
C {CP2_test.sym} -380 20920 0 0 {name=x94}
C {devices/lab_pin.sym} -3000 18720 0 0 {name=p388 sig_type=std_logic lab=oin1
value=0}
C {devices/lab_pin.sym} -3000 18740 0 0 {name=p389 sig_type=std_logic lab=oin2
value=0}
C {devices/lab_pin.sym} -3000 18760 0 0 {name=p390 sig_type=std_logic lab=oin3
value=0}
C {devices/lab_pin.sym} -3000 18780 0 0 {name=p391 sig_type=std_logic lab=oin4
value=0}
C {devices/lab_pin.sym} -3000 18800 0 0 {name=p392 sig_type=std_logic lab=oin5
value=0}
C {devices/lab_pin.sym} -3000 18820 0 0 {name=p393 sig_type=std_logic lab=oin6
value=0}
C {devices/lab_pin.sym} -3000 18840 0 0 {name=p394 sig_type=std_logic lab=oin7
value=0}
C {devices/lab_pin.sym} -3000 18860 0 0 {name=p395 sig_type=std_logic lab=oin8
value=0}
C {devices/lab_pin.sym} -2310 18720 0 0 {name=p402 sig_type=std_logic lab=oin1
value=0}
C {devices/lab_pin.sym} -2310 18740 0 0 {name=p403 sig_type=std_logic lab=oin2
value=0}
C {devices/lab_pin.sym} -2310 18760 0 0 {name=p404 sig_type=std_logic lab=oin3
value=0}
C {devices/lab_pin.sym} -2310 18780 0 0 {name=p405 sig_type=std_logic lab=oin4
value=0}
C {devices/lab_pin.sym} -2310 18800 0 0 {name=p406 sig_type=std_logic lab=oin5
value=0}
C {devices/lab_pin.sym} -2310 18820 0 0 {name=p407 sig_type=std_logic lab=oin6
value=0}
C {devices/lab_pin.sym} -2310 18840 0 0 {name=p408 sig_type=std_logic lab=oin7
value=0}
C {devices/lab_pin.sym} -2310 18860 0 0 {name=p409 sig_type=std_logic lab=oin8
value=0}
C {devices/lab_pin.sym} -1660 18720 0 0 {name=p416 sig_type=std_logic lab=oin1
value=0}
C {devices/lab_pin.sym} -1660 18740 0 0 {name=p417 sig_type=std_logic lab=oin2
value=0}
C {devices/lab_pin.sym} -1660 18760 0 0 {name=p418 sig_type=std_logic lab=oin3
value=0}
C {devices/lab_pin.sym} -1660 18780 0 0 {name=p419 sig_type=std_logic lab=oin4
value=0}
C {devices/lab_pin.sym} -1660 18800 0 0 {name=p420 sig_type=std_logic lab=oin5
value=0}
C {devices/lab_pin.sym} -1660 18820 0 0 {name=p421 sig_type=std_logic lab=oin6
value=0}
C {devices/lab_pin.sym} -1660 18840 0 0 {name=p422 sig_type=std_logic lab=oin7
value=0}
C {devices/lab_pin.sym} -1660 18860 0 0 {name=p423 sig_type=std_logic lab=oin8
value=0}
C {devices/lab_pin.sym} -910 18710 0 0 {name=p430 sig_type=std_logic lab=oin1
value=0}
C {devices/lab_pin.sym} -910 18730 0 0 {name=p431 sig_type=std_logic lab=oin2
value=0}
C {devices/lab_pin.sym} -910 18750 0 0 {name=p432 sig_type=std_logic lab=oin3
value=0}
C {devices/lab_pin.sym} -910 18770 0 0 {name=p433 sig_type=std_logic lab=oin4
value=0}
C {devices/lab_pin.sym} -910 18790 0 0 {name=p434 sig_type=std_logic lab=oin5
value=0}
C {devices/lab_pin.sym} -910 18810 0 0 {name=p435 sig_type=std_logic lab=oin6
value=0}
C {devices/lab_pin.sym} -910 18830 0 0 {name=p436 sig_type=std_logic lab=oin7
value=0}
C {devices/lab_pin.sym} -910 18850 0 0 {name=p437 sig_type=std_logic lab=oin8
value=0}
C {devices/lab_pin.sym} -3960 16910 0 1 {name=p586 sig_type=std_logic lab=oin1
value=0}
C {devices/lab_pin.sym} -3960 16930 0 1 {name=p587 sig_type=std_logic lab=oin2
value=0}
C {devices/lab_pin.sym} -3960 16950 0 1 {name=p588 sig_type=std_logic lab=oin3
value=0}
C {devices/lab_pin.sym} -3960 16970 0 1 {name=p589 sig_type=std_logic lab=oin4
value=0}
C {devices/lab_pin.sym} -3960 16990 0 1 {name=p590 sig_type=std_logic lab=oin5
value=0}
C {devices/lab_pin.sym} -3960 17010 0 1 {name=p591 sig_type=std_logic lab=oin6
value=0}
C {devices/lab_pin.sym} -3960 17030 0 1 {name=p592 sig_type=std_logic lab=oin7
value=0}
C {devices/lab_pin.sym} -3960 17050 0 1 {name=p593 sig_type=std_logic lab=oin8
value=0}
C {devices/lab_pin.sym} -2550 19840 0 1 {name=p445 sig_type=std_logic lab=oin1
value=0}
C {devices/lab_pin.sym} -2550 19860 0 1 {name=p446 sig_type=std_logic lab=oin2
value=0}
C {devices/lab_pin.sym} -2550 19880 0 1 {name=p447 sig_type=std_logic lab=oin3
value=0}
C {devices/lab_pin.sym} -2550 19900 0 1 {name=p448 sig_type=std_logic lab=oin4
value=0}
C {devices/lab_pin.sym} -2550 19920 0 1 {name=p449 sig_type=std_logic lab=oin5
value=0}
C {devices/lab_pin.sym} -2550 19940 0 1 {name=p450 sig_type=std_logic lab=oin6
value=0}
C {devices/lab_pin.sym} -2550 19960 0 1 {name=p451 sig_type=std_logic lab=oin7
value=0}
C {devices/lab_pin.sym} -2550 19980 0 1 {name=p452 sig_type=std_logic lab=oin8
value=0}
C {devices/lab_pin.sym} -1790 19850 0 1 {name=p459 sig_type=std_logic lab=oin1
value=0}
C {devices/lab_pin.sym} -1790 19870 0 1 {name=p460 sig_type=std_logic lab=oin2
value=0}
C {devices/lab_pin.sym} -1790 19890 0 1 {name=p461 sig_type=std_logic lab=oin3
value=0}
C {devices/lab_pin.sym} -1790 19910 0 1 {name=p462 sig_type=std_logic lab=oin4
value=0}
C {devices/lab_pin.sym} -1790 19930 0 1 {name=p463 sig_type=std_logic lab=oin5
value=0}
C {devices/lab_pin.sym} -1790 19950 0 1 {name=p464 sig_type=std_logic lab=oin6
value=0}
C {devices/lab_pin.sym} -1790 19970 0 1 {name=p465 sig_type=std_logic lab=oin7
value=0}
C {devices/lab_pin.sym} -1790 19990 0 1 {name=p466 sig_type=std_logic lab=oin8
value=0}
C {devices/lab_pin.sym} -1140 19850 0 1 {name=p473 sig_type=std_logic lab=oin1
value=0}
C {devices/lab_pin.sym} -1140 19870 0 1 {name=p474 sig_type=std_logic lab=oin2
value=0}
C {devices/lab_pin.sym} -1140 19890 0 1 {name=p475 sig_type=std_logic lab=oin3
value=0}
C {devices/lab_pin.sym} -1140 19910 0 1 {name=p476 sig_type=std_logic lab=oin4
value=0}
C {devices/lab_pin.sym} -1140 19930 0 1 {name=p477 sig_type=std_logic lab=oin5
value=0}
C {devices/lab_pin.sym} -1140 19950 0 1 {name=p478 sig_type=std_logic lab=oin6
value=0}
C {devices/lab_pin.sym} -1140 19970 0 1 {name=p479 sig_type=std_logic lab=oin7
value=0}
C {devices/lab_pin.sym} -1140 19990 0 1 {name=p480 sig_type=std_logic lab=oin8
value=0}
C {devices/lab_pin.sym} -450 19850 0 1 {name=p487 sig_type=std_logic lab=oin1
value=0}
C {devices/lab_pin.sym} -450 19870 0 1 {name=p488 sig_type=std_logic lab=oin2
value=0}
C {devices/lab_pin.sym} -450 19890 0 1 {name=p489 sig_type=std_logic lab=oin3
value=0}
C {devices/lab_pin.sym} -450 19910 0 1 {name=p490 sig_type=std_logic lab=oin4
value=0}
C {devices/lab_pin.sym} -450 19930 0 1 {name=p491 sig_type=std_logic lab=oin5
value=0}
C {devices/lab_pin.sym} -450 19950 0 1 {name=p492 sig_type=std_logic lab=oin6
value=0}
C {devices/lab_pin.sym} -450 19970 0 1 {name=p493 sig_type=std_logic lab=oin7
value=0}
C {devices/lab_pin.sym} -450 19990 0 1 {name=p494 sig_type=std_logic lab=oin8
value=0}
C {devices/lab_pin.sym} 250 19820 0 1 {name=p501 sig_type=std_logic lab=oin1
value=0}
C {devices/lab_pin.sym} 250 19840 0 1 {name=p502 sig_type=std_logic lab=oin2
value=0}
C {devices/lab_pin.sym} 250 19860 0 1 {name=p503 sig_type=std_logic lab=oin3
value=0}
C {devices/lab_pin.sym} 250 19880 0 1 {name=p504 sig_type=std_logic lab=oin4
value=0}
C {devices/lab_pin.sym} 250 19900 0 1 {name=p505 sig_type=std_logic lab=oin5
value=0}
C {devices/lab_pin.sym} 250 19920 0 1 {name=p506 sig_type=std_logic lab=oin6
value=0}
C {devices/lab_pin.sym} 250 19940 0 1 {name=p507 sig_type=std_logic lab=oin7
value=0}
C {devices/lab_pin.sym} 250 19960 0 1 {name=p508 sig_type=std_logic lab=oin8
value=0}
C {devices/lab_pin.sym} -3330 20800 0 0 {name=p516 sig_type=std_logic lab=oin1
value=0}
C {devices/lab_pin.sym} -3330 20820 0 0 {name=p517 sig_type=std_logic lab=oin2
value=0}
C {devices/lab_pin.sym} -3330 20840 0 0 {name=p518 sig_type=std_logic lab=oin3
value=0}
C {devices/lab_pin.sym} -3330 20860 0 0 {name=p519 sig_type=std_logic lab=oin4
value=0}
C {devices/lab_pin.sym} -3330 20880 0 0 {name=p520 sig_type=std_logic lab=oin5
value=0}
C {devices/lab_pin.sym} -3330 20900 0 0 {name=p521 sig_type=std_logic lab=oin6
value=0}
C {devices/lab_pin.sym} -3330 20920 0 0 {name=p522 sig_type=std_logic lab=oin7
value=0}
C {devices/lab_pin.sym} -3330 20940 0 0 {name=p523 sig_type=std_logic lab=oin8
value=0}
C {devices/lab_pin.sym} -2630 20830 0 0 {name=p530 sig_type=std_logic lab=oin1
value=0}
C {devices/lab_pin.sym} -2630 20850 0 0 {name=p531 sig_type=std_logic lab=oin2
value=0}
C {devices/lab_pin.sym} -2630 20870 0 0 {name=p532 sig_type=std_logic lab=oin3
value=0}
C {devices/lab_pin.sym} -2630 20890 0 0 {name=p533 sig_type=std_logic lab=oin4
value=0}
C {devices/lab_pin.sym} -2630 20910 0 0 {name=p534 sig_type=std_logic lab=oin5
value=0}
C {devices/lab_pin.sym} -2630 20930 0 0 {name=p535 sig_type=std_logic lab=oin6
value=0}
C {devices/lab_pin.sym} -2630 20950 0 0 {name=p536 sig_type=std_logic lab=oin7
value=0}
C {devices/lab_pin.sym} -2630 20970 0 0 {name=p537 sig_type=std_logic lab=oin8
value=0}
C {devices/lab_pin.sym} -1940 20830 0 0 {name=p544 sig_type=std_logic lab=oin1
value=0}
C {devices/lab_pin.sym} -1940 20850 0 0 {name=p545 sig_type=std_logic lab=oin2
value=0}
C {devices/lab_pin.sym} -1940 20870 0 0 {name=p546 sig_type=std_logic lab=oin3
value=0}
C {devices/lab_pin.sym} -1940 20890 0 0 {name=p547 sig_type=std_logic lab=oin4
value=0}
C {devices/lab_pin.sym} -1940 20910 0 0 {name=p548 sig_type=std_logic lab=oin5
value=0}
C {devices/lab_pin.sym} -1940 20930 0 0 {name=p549 sig_type=std_logic lab=oin6
value=0}
C {devices/lab_pin.sym} -1940 20950 0 0 {name=p550 sig_type=std_logic lab=oin7
value=0}
C {devices/lab_pin.sym} -1940 20970 0 0 {name=p551 sig_type=std_logic lab=oin8
value=0}
C {devices/lab_pin.sym} -1290 20830 0 0 {name=p558 sig_type=std_logic lab=oin1
value=0}
C {devices/lab_pin.sym} -1290 20850 0 0 {name=p559 sig_type=std_logic lab=oin2
value=0}
C {devices/lab_pin.sym} -1290 20870 0 0 {name=p560 sig_type=std_logic lab=oin3
value=0}
C {devices/lab_pin.sym} -1290 20890 0 0 {name=p561 sig_type=std_logic lab=oin4
value=0}
C {devices/lab_pin.sym} -1290 20910 0 0 {name=p562 sig_type=std_logic lab=oin5
value=0}
C {devices/lab_pin.sym} -1290 20930 0 0 {name=p563 sig_type=std_logic lab=oin6
value=0}
C {devices/lab_pin.sym} -1290 20950 0 0 {name=p564 sig_type=std_logic lab=oin7
value=0}
C {devices/lab_pin.sym} -1290 20970 0 0 {name=p565 sig_type=std_logic lab=oin8
value=0}
C {devices/lab_pin.sym} -530 20820 0 0 {name=p572 sig_type=std_logic lab=oin1
value=0}
C {devices/lab_pin.sym} -530 20840 0 0 {name=p573 sig_type=std_logic lab=oin2
value=0}
C {devices/lab_pin.sym} -530 20860 0 0 {name=p574 sig_type=std_logic lab=oin3
value=0}
C {devices/lab_pin.sym} -530 20880 0 0 {name=p575 sig_type=std_logic lab=oin4
value=0}
C {devices/lab_pin.sym} -530 20900 0 0 {name=p576 sig_type=std_logic lab=oin5
value=0}
C {devices/lab_pin.sym} -530 20920 0 0 {name=p577 sig_type=std_logic lab=oin6
value=0}
C {devices/lab_pin.sym} -530 20940 0 0 {name=p578 sig_type=std_logic lab=oin7
value=0}
C {devices/lab_pin.sym} -530 20960 0 0 {name=p579 sig_type=std_logic lab=oin8
value=0}
C {devices/lab_wire.sym} 1090 16050 0 0 {name=p594 sig_type=std_logic lab=outr1

}
C {devices/lab_wire.sym} 1400 16040 0 0 {name=p595 sig_type=std_logic lab=outr2


}
C {devices/lab_wire.sym} 1250 16040 0 0 {name=p596 sig_type=std_logic lab=Vcm_det3



}
C {devices/lab_wire.sym} 2030 16070 0 1 {name=p599 sig_type=std_logic lab=Vcm3




}
C {devices/lab_wire.sym} 1800 15980 0 1 {name=p600 sig_type=std_logic lab=Vcm3




}
C {devices/lab_wire.sym} 1730 16050 0 0 {name=p601 sig_type=std_logic lab=Vbcmfb




}
C {sky130_fd_pr/pfet_01v8.sym} 1130 16110 0 0 {name=M122
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1360 16110 0 1 {name=M123
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1130 15970 0 0 {name=M124
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1360 15970 0 1 {name=M125
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1530 15980 0 0 {name=M126
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1750 15980 0 1 {name=M127
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1570 16120 0 1 {name=M128
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1710 16120 0 0 {name=M129
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1930 16000 0 0 {name=M130
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 2160 16000 0 1 {name=M131
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1930 16140 0 0 {name=M132
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 2160 16140 0 1 {name=M133
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/code.sym} 890 15930 0 0 {name=TT_MODELS1
only_toplevel=true
format="tcleval( @value )"
value="
** opencircuitdesign pdks install
.lib $::SKYWATER_MODELS/sky130.lib.spice tt

"
spice_ignore=false}
C {sky130_fd_pr/nfet_01v8.sym} 1460 16240 0 0 {name=M134
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1800 16230 0 1 {name=M135
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1330 15750 0 1 {name=M136
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1500 15750 0 0 {name=M137
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} 1250 15910 0 0 {name=p602 sig_type=std_logic lab=Vdd




}
C {devices/lab_wire.sym} 1360 15720 0 0 {name=p603 sig_type=std_logic lab=Vdd




}
C {devices/lab_wire.sym} 2040 15940 0 0 {name=p604 sig_type=std_logic lab=Vdd




}
C {devices/lab_wire.sym} 1250 16170 0 0 {name=p605 sig_type=std_logic lab=gnd





}
C {devices/lab_wire.sym} 1610 16290 0 0 {name=p606 sig_type=std_logic lab=gnd





}
C {devices/lab_wire.sym} 2040 16200 0 0 {name=p607 sig_type=std_logic lab=gnd





}
C {devices/lab_wire.sym} 1460 15720 0 0 {name=p608 sig_type=std_logic lab=Vdd




}
C {devices/lab_wire.sym} 1270 16110 0 0 {name=p609 sig_type=std_logic lab=Vdd




}
C {devices/lab_wire.sym} 1240 15970 0 0 {name=p610 sig_type=std_logic lab=gnd





}
C {devices/lab_wire.sym} 2070 16140 0 0 {name=p611 sig_type=std_logic lab=Vdd




}
C {devices/lab_wire.sym} 2050 16000 0 0 {name=p612 sig_type=std_logic lab=gnd





}
C {devices/lab_wire.sym} 1630 16170 0 0 {name=p613 sig_type=std_logic lab=gnd





}
C {devices/lab_wire.sym} 1640 15980 0 0 {name=p614 sig_type=std_logic lab=Vdd




}
C {devices/lab_wire.sym} 1490 15980 0 0 {name=p615 sig_type=std_logic lab=Vcm_det3



}
C {devices/lab_wire.sym} 1420 15800 0 0 {name=p616 sig_type=std_logic lab=Vdd




}
C {sky130_fd_pr/pfet_01v8.sym} 1620 15860 0 0 {name=M138
L=0.5
W=0.5
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} 1640 15810 0 0 {name=p617 sig_type=std_logic lab=Vdd




}
C {devices/lab_wire.sym} 1550 15860 0 1 {name=p618 sig_type=std_logic lab=Vbiasp





}
C {sky130_fd_pr/pfet_01v8.sym} 1220 16270 0 0 {name=M139
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} 1240 16220 0 0 {name=p619 sig_type=std_logic lab=Vdd
}
C {devices/gnd.sym} 1240 16460 0 0 {name=l29 lab=GND}
C {devices/lab_wire.sym} 1180 16380 0 0 {name=p620 sig_type=std_logic lab=Vbias1

}
C {sky130_fd_pr/nfet_01v8.sym} 1220 16410 0 0 {name=M140
L=0.5
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/lab_wire.sym} 1200 16300 0 0 {name=p621 sig_type=std_logic lab=Vbiasp

}
C {devices/lab_pin.sym} -7910 15620 1 0 {name=p622 sig_type=std_logic lab=vdd}
C {sky130_fd_pr/pfet_01v8_lvt.sym} -7940 15690 0 0 {name=M141
L=4
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} -7940 15800 0 0 {name=M142
L=0.5
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} -7940 15900 0 0 {name=M143
L=4
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {devices/lab_pin.sym} -7920 15960 2 0 {name=p623 sig_type=std_logic lab=gnd}
C {devices/lab_wire.sym} -7850 15860 0 0 {name=p624 sig_type=std_logic lab=Vc1-
}
C {devices/lab_wire.sym} -7860 15760 0 0 {name=p625 sig_type=std_logic lab=Vc1+
}
C {devices/lab_wire.sym} -8410 15840 0 0 {name=p43 sig_type=std_logic lab=Vc1+
}
C {devices/lab_wire.sym} -8100 15850 0 0 {name=p44 sig_type=std_logic lab=Vc1+
}
C {devices/lab_pin.sym} 2410 15900 1 0 {name=p626 sig_type=std_logic lab=vdd}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2380 15970 0 0 {name=M144
L=4
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2380 16180 0 0 {name=M146
L=4
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {devices/lab_pin.sym} 2400 16240 2 0 {name=p627 sig_type=std_logic lab=gnd}
C {devices/lab_wire.sym} 2470 16140 0 0 {name=p628 sig_type=std_logic lab=Vc2+
}
C {devices/lab_wire.sym} 1890 16080 0 0 {name=p597 sig_type=std_logic lab=Vc2+
}
C {devices/lab_wire.sym} 2200 16070 0 0 {name=p598 sig_type=std_logic lab=Vc2+
}
C {sky130_fd_pr/nfet_01v8.sym} 1780 16410 0 0 {name=M145
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1620 16410 0 1 {name=M147
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 1600 16440 0 0 {name=l30 lab=GND}
C {devices/gnd.sym} 1800 16440 0 0 {name=l32 lab=GND}
C {devices/lab_wire.sym} 1720 16410 0 0 {name=p629 sig_type=std_logic lab=Vbcmfb




}
C {devices/lab_pin.sym} -1220 15520 3 0 {name=p630 sig_type=std_logic lab=o1}
C {devices/lab_pin.sym} -510 15510 3 0 {name=p631 sig_type=std_logic lab=o2}
C {devices/lab_pin.sym} 200 16700 2 0 {name=p632 sig_type=std_logic lab=o1}
C {devices/lab_pin.sym} -500 16730 2 0 {name=p633 sig_type=std_logic lab=o2}
C {devices/lab_pin.sym} -335 16750 3 0 {name=p634 sig_type=std_logic lab=o3}
C {devices/lab_pin.sym} -995 16750 3 0 {name=p635 sig_type=std_logic lab=o4}
C {devices/lab_pin.sym} -1190 16730 2 0 {name=p636 sig_type=std_logic lab=o3}
C {devices/lab_pin.sym} -1840 16730 2 0 {name=p637 sig_type=std_logic lab=o4}
C {devices/lab_pin.sym} -1715 16750 3 0 {name=p638 sig_type=std_logic lab=o5}
C {devices/lab_pin.sym} -2370 16660 3 0 {name=p639 sig_type=std_logic lab=o6}
C {devices/lab_pin.sym} -2600 16720 2 0 {name=p640 sig_type=std_logic lab=o5}
C {devices/lab_pin.sym} -3140 16650 3 0 {name=p641 sig_type=std_logic lab=o7}
C {devices/lab_pin.sym} -3030 17730 3 0 {name=p642 sig_type=std_logic lab=o8}
C {devices/lab_pin.sym} -3380 17680 0 0 {name=p643 sig_type=std_logic lab=o6}
C {devices/lab_pin.sym} -2680 17710 0 0 {name=p644 sig_type=std_logic lab=o7}
C {devices/lab_pin.sym} -2185 17730 3 0 {name=p645 sig_type=std_logic lab=o9}
C {devices/lab_pin.sym} -1990 17710 0 0 {name=p646 sig_type=std_logic lab=o8}
C {devices/lab_pin.sym} -1580 17730 3 0 {name=p647 sig_type=std_logic lab=o10}
C {devices/lab_pin.sym} -1340 17710 0 0 {name=p648 sig_type=std_logic lab=o9}
C {devices/lab_pin.sym} -580 17700 0 0 {name=p649 sig_type=std_logic lab=o10}
C {devices/lab_pin.sym} -940 17640 3 0 {name=p650 sig_type=std_logic lab=o11}
C {devices/lab_pin.sym} -1145 18810 3 0 {name=p651 sig_type=std_logic lab=ob1}
C {devices/lab_pin.sym} -450 18800 3 0 {name=p652 sig_type=std_logic lab=ob2}
C {devices/lab_pin.sym} -255 20040 3 0 {name=p653 sig_type=std_logic lab=ob3}
C {devices/lab_pin.sym} 250 19990 2 0 {name=p654 sig_type=std_logic lab=ob1}
C {devices/lab_pin.sym} -450 20020 2 0 {name=p655 sig_type=std_logic lab=ob2}
C {devices/lab_pin.sym} -1140 20020 2 0 {name=p656 sig_type=std_logic lab=ob3}
C {devices/lab_pin.sym} -990 20040 3 0 {name=p657 sig_type=std_logic lab=ob4}
C {devices/lab_pin.sym} -1650 20040 3 0 {name=p658 sig_type=std_logic lab=ob5}
C {devices/lab_pin.sym} -1790 20020 2 0 {name=p659 sig_type=std_logic lab=ob4}
C {devices/lab_pin.sym} -2330 19950 3 0 {name=p660 sig_type=std_logic lab=ob6}
C {devices/lab_pin.sym} -2550 20010 2 0 {name=p661 sig_type=std_logic lab=ob5}
C {devices/lab_pin.sym} -2995 19940 3 0 {name=p662 sig_type=std_logic lab=ob7}
C {devices/lab_pin.sym} -3330 20970 0 0 {name=p663 sig_type=std_logic lab=ob6}
C {devices/lab_pin.sym} -2960 21020 3 0 {name=p664 sig_type=std_logic lab=ob8}
C {devices/lab_pin.sym} -2630 21000 0 0 {name=p665 sig_type=std_logic lab=ob7}
C {devices/lab_pin.sym} -2230 21020 3 0 {name=p666 sig_type=std_logic lab=ob9}
C {devices/lab_pin.sym} -1940 21000 0 0 {name=p667 sig_type=std_logic lab=ob8}
C {devices/lab_pin.sym} -1290 21000 0 0 {name=p668 sig_type=std_logic lab=ob9}
C {devices/lab_pin.sym} -1510 21020 3 0 {name=p669 sig_type=std_logic lab=ob10}
C {devices/lab_pin.sym} -530 20990 0 0 {name=p670 sig_type=std_logic lab=ob10}
C {devices/gnd.sym} -4720 15200 0 0 {name=l33 lab=GND}
C {devices/lab_wire.sym} -4720 14940 0 0 {name=p671 sig_type=std_logic lab=Vdd
}
C {devices/lab_wire.sym} -4880 15060 0 0 {name=p672 sig_type=std_logic lab=vo1



}
C {devices/lab_wire.sym} -4570 15070 0 1 {name=p673 sig_type=std_logic lab=vo1



}
C {devices/lab_wire.sym} -4740 15070 0 1 {name=p674 sig_type=std_logic lab=vin+




}
C {sky130_fd_pr/nfet_01v8.sym} -4840 15000 0 0 {name=M148
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -4610 15000 0 1 {name=M149
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -4730 15000 0 0 {name=l34 lab=GND}
C {devices/gnd.sym} -5000 18100 0 0 {name=l35 lab=GND}
C {devices/lab_wire.sym} -5000 17840 0 0 {name=p676 sig_type=std_logic lab=Vdd
}
C {devices/lab_wire.sym} -5160 17960 0 0 {name=p677 sig_type=std_logic lab=vo2



}
C {devices/lab_wire.sym} -4850 17970 0 1 {name=p678 sig_type=std_logic lab=vo2



}
C {devices/lab_wire.sym} -5020 17970 0 1 {name=p679 sig_type=std_logic lab=vin-




}
C {sky130_fd_pr/nfet_01v8.sym} -5120 17900 0 0 {name=M152
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} -4890 17900 0 1 {name=M153
L=0.5
W=0.5
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} -5010 17900 0 0 {name=l36 lab=GND}
C {sky130_fd_pr/pfet3_01v8_lvt.sym} -5120 18040 0 0 {name=M154
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8_lvt.sym} -4890 18040 0 1 {name=M155
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8_lvt.sym} -4840 15140 0 0 {name=M150
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet3_01v8_lvt.sym} -4610 15140 0 1 {name=M151
L=0.15
W=1
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
