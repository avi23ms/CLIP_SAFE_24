v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {cp1_buffer_xschem.sym} -50 10 0 0 {name=x1}
