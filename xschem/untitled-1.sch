v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {type=primitive
format="@name @pinlist @symname"
template="name=x1"
}
E {}
L 4 -170 -100 90 -100 {}
L 4 -170 100 90 100 {}
L 4 -170 -100 -170 100 {}
L 4 90 -100 90 100 {}
L 4 -100 -120 -100 -100 {}
L 4 -190 90 -170 90 {}
L 4 90 -50 110 -50 {}
L 4 -190 -90 -170 -90 {}
L 4 -190 -70 -170 -70 {}
L 4 -190 -50 -170 -50 {}
L 4 -190 -30 -170 -30 {}
L 4 -190 -10 -170 -10 {}
L 4 -190 10 -170 10 {}
L 4 -190 30 -170 30 {}
L 4 -190 50 -170 50 {}
L 4 90 -90 110 -90 {}
L 4 90 -70 110 -70 {}
L 4 0 -120 0 -100 {}
L 4 20 -120 20 -100 {}
L 4 90 -20 110 -20 {}
L 4 90 0 110 0 {}
L 4 90 20 110 20 {}
L 4 90 40 110 40 {}
L 4 90 60 110 60 {}
L 4 90 80 110 80 {}
L 7 -40 100 -40 120 {}
L 7 -40 -120 -40 -100 {}
B 5 -42.5 117.5 -37.5 122.5 {name=gnd dir=inout}
B 5 -102.5 -122.5 -97.5 -117.5 {name=clk_in dir=in}
B 5 -192.5 87.5 -187.5 92.5 {name=vin dir=in}
B 5 107.5 -52.5 112.5 -47.5 {name=vout dir=out}
B 5 -192.5 -92.5 -187.5 -87.5 {name=in1 dir=in}
B 5 -192.5 -72.5 -187.5 -67.5 {name=in2 dir=in}
B 5 -192.5 -52.5 -187.5 -47.5 {name=in3 dir=in}
B 5 -192.5 -32.5 -187.5 -27.5 {name=in4 dir=in}
B 5 -192.5 -12.5 -187.5 -7.5 {name=in5 dir=in}
B 5 -192.5 7.5 -187.5 12.5 {name=in6 dir=in}
B 5 -192.5 27.5 -187.5 32.5 {name=in7 dir=in}
B 5 -192.5 47.5 -187.5 52.5 {name=in8 dir=in}
B 5 -42.5 -122.5 -37.5 -117.5 {name=vdd dir=inout}
B 5 107.5 -92.5 112.5 -87.5 {name=clk dir=out}
B 5 107.5 -72.5 112.5 -67.5 {name=clkb dir=out}
B 5 -2.5 -122.5 2.5 -117.5 {name=node1 dir=out}
B 5 17.5 -122.5 22.5 -117.5 {name=node2 dir=out}
B 5 107.5 -22.5 112.5 -17.5 {name=n1 dir=out}
B 5 107.5 -2.5 112.5 2.5 {name=n2 dir=out}
B 5 107.5 17.5 112.5 22.5 {name=n3 dir=out}
B 5 107.5 37.5 112.5 42.5 {name=n4 dir=out}
B 5 107.5 57.5 112.5 62.5 {name=n5 dir=out}
B 5 107.5 77.5 112.5 82.5 {name=n6 dir=out}
T {@name} 95 -112 0 0 0.2 0.2 {}
T {gnd} -36 95 1 1 0.2 0.2 {}
T {clk_in} -96 -95 1 0 0.2 0.2 {}
T {vin} -165 86 0 0 0.2 0.2 {}
T {vout} 85 -54 0 1 0.2 0.2 {}
T {in1} -165 -94 0 0 0.2 0.2 {}
T {in2} -165 -74 0 0 0.2 0.2 {}
T {in3} -165 -54 0 0 0.2 0.2 {}
T {in4} -165 -34 0 0 0.2 0.2 {}
T {in5} -165 -14 0 0 0.2 0.2 {}
T {in6} -165 6 0 0 0.2 0.2 {}
T {in7} -165 26 0 0 0.2 0.2 {}
T {in8} -165 46 0 0 0.2 0.2 {}
T {vdd} -44 -95 3 1 0.2 0.2 {}
T {clk} 85 -94 0 1 0.2 0.2 {}
T {clkb} 85 -74 0 1 0.2 0.2 {}
T {node1} -4 -95 3 1 0.2 0.2 {}
T {node2} 16 -95 3 1 0.2 0.2 {}
T {n1} 85 -24 0 1 0.2 0.2 {}
T {n2} 85 -4 0 1 0.2 0.2 {}
T {n3} 85 16 0 1 0.2 0.2 {}
T {n4} 85 36 0 1 0.2 0.2 {}
T {n5} 85 56 0 1 0.2 0.2 {}
T {n6} 85 76 0 1 0.2 0.2 {}
