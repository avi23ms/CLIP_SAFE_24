v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {buffer_and_gate.sym} 0 10 0 0 {}
C {devices/gnd.sym} 0 140 0 0 {name=l1 lab=GND}
