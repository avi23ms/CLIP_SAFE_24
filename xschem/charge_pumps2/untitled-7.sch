v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {comparator_lvs.sym} -20 -30 0 0 {name=x1}
C {latch_lvs.sym} 330 -20 0 0 {name=x2}
