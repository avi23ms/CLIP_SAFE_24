v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N -310 -60 -280 -60 {
lab=in1}
N -310 -40 -280 -40 {
lab=clk}
N 20 -60 40 -60 {
lab=vdd}
N 20 -40 50 -40 {
lab=#net1}
N 20 -20 50 -20 {
lab=gnd}
N 50 -40 170 -40 {
lab=#net1}
N -320 30 -290 30 {
lab=in2}
N -320 50 -290 50 {
lab=clk}
N 10 30 30 30 {
lab=vdd}
N 10 50 40 50 {
lab=#net1}
N 10 70 40 70 {
lab=gnd}
N 40 50 160 50 {
lab=#net1}
N -310 120 -280 120 {
lab=in3}
N -310 140 -280 140 {
lab=clk}
N 20 120 40 120 {
lab=vdd}
N 20 140 50 140 {
lab=#net1}
N 20 160 50 160 {
lab=gnd}
N 50 140 170 140 {
lab=#net1}
N -310 200 -280 200 {
lab=in4}
N -310 220 -280 220 {
lab=clk}
N 20 200 40 200 {
lab=vdd}
N 20 220 50 220 {
lab=#net1}
N 20 240 50 240 {
lab=gnd}
N 50 220 170 220 {
lab=#net1}
N -300 280 -270 280 {
lab=in5}
N -300 300 -270 300 {
lab=clk}
N 30 280 50 280 {
lab=vdd}
N 30 300 60 300 {
lab=#net1}
N 30 320 60 320 {
lab=gnd}
N -310 370 -280 370 {
lab=in6}
N -310 390 -280 390 {
lab=clk}
N 20 370 40 370 {
lab=vdd}
N 20 390 50 390 {
lab=#net1}
N 20 410 50 410 {
lab=gnd}
N 50 390 170 390 {
lab=#net1}
N -300 460 -270 460 {
lab=in7}
N -300 480 -270 480 {
lab=clk}
N 30 460 50 460 {
lab=vdd}
N 30 480 60 480 {
lab=#net1}
N 30 500 60 500 {
lab=gnd}
N 60 480 180 480 {
lab=#net1}
N -300 540 -270 540 {
lab=in8}
N -300 560 -270 560 {
lab=clk}
N 30 540 50 540 {
lab=vdd}
N 30 560 60 560 {
lab=#net1}
N 30 580 60 580 {
lab=gnd}
N 60 560 180 560 {
lab=#net1}
N 170 -40 170 480 {
lab=#net1}
N 160 50 170 50 {
lab=#net1}
N 60 300 170 300 {
lab=#net1}
N 330 -100 330 -50 {
lab=#net1}
N 170 -40 330 -40 {
lab=#net1}
N 330 -50 330 -40 {
lab=#net1}
N 350 -100 350 -40 {
lab=#net2}
N 350 -40 420 -40 {
lab=#net2}
N 170 480 170 560 {
lab=#net1}
N 860 -60 890 -60 {
lab=in1}
N 860 -40 890 -40 {
lab=clkb}
N 540 -60 560 -60 {
lab=vdd}
N 530 -40 560 -40 {
lab=#net2}
N 530 -20 560 -20 {
lab=gnd}
N 410 -40 530 -40 {
lab=#net2}
N 870 30 900 30 {
lab=in2}
N 870 50 900 50 {
lab=clkb}
N 550 30 570 30 {
lab=vdd}
N 540 50 570 50 {
lab=#net2}
N 540 70 570 70 {
lab=gnd}
N 420 50 540 50 {
lab=#net2}
N 860 120 890 120 {
lab=in3}
N 860 140 890 140 {
lab=clkb}
N 540 120 560 120 {
lab=vdd}
N 530 140 560 140 {
lab=#net2}
N 530 160 560 160 {
lab=gnd}
N 410 140 530 140 {
lab=#net2}
N 860 200 890 200 {
lab=in4}
N 860 220 890 220 {
lab=clkb}
N 540 200 560 200 {
lab=vdd}
N 530 220 560 220 {
lab=#net2}
N 530 240 560 240 {
lab=gnd}
N 410 220 530 220 {
lab=#net2}
N 850 280 880 280 {
lab=in5}
N 850 300 880 300 {
lab=clkb}
N 530 280 550 280 {
lab=vdd}
N 520 300 550 300 {
lab=#net2}
N 520 320 550 320 {
lab=gnd}
N 860 370 890 370 {
lab=in6}
N 860 390 890 390 {
lab=clkb}
N 540 370 560 370 {
lab=vdd}
N 530 390 560 390 {
lab=#net2}
N 530 410 560 410 {
lab=gnd}
N 410 390 530 390 {
lab=#net2}
N 850 460 880 460 {
lab=in7}
N 850 480 880 480 {
lab=clkb}
N 530 460 550 460 {
lab=vdd}
N 520 480 550 480 {
lab=#net2}
N 520 500 550 500 {
lab=gnd}
N 400 480 520 480 {
lab=#net2}
N 850 540 880 540 {
lab=in8}
N 850 560 880 560 {
lab=clkb}
N 530 540 550 540 {
lab=vdd}
N 520 560 550 560 {
lab=#net2}
N 520 580 550 580 {
lab=gnd}
N 400 560 520 560 {
lab=#net2}
N 410 -40 410 480 {
lab=#net2}
N 410 50 420 50 {
lab=#net2}
N 410 300 520 300 {
lab=#net2}
N 410 480 410 560 {
lab=#net2}
N 180 560 240 560 {
lab=#net1}
N 240 560 240 610 {
lab=#net1}
N 300 560 400 560 {
lab=#net2}
N 300 560 300 600 {
lab=#net2}
N 240 900 240 960 {
lab=out}
N 350 -450 350 -400 {
lab=in}
N 260 -450 350 -450 {
lab=in}
N -170 860 -170 890 {
lab=vdd}
N -20 940 0 940 {
lab=clk}
N -20 960 0 960 {
lab=clkb}
N -380 920 -320 920 {
lab=clk_in}
N 240 -120 240 -100 {
lab=clk}
N 470 -120 470 -100 {
lab=clkb}
N 0 30 10 30 {
lab=vdd}
N 0 70 10 70 {
lab=gnd}
N 10 120 20 120 {
lab=vdd}
N 10 160 20 160 {
lab=gnd}
N 10 140 30 140 {
lab=#net1}
N 0 50 20 50 {
lab=#net1}
N -190 -90 30 -90 {
lab=vdd}
N 30 -90 30 -60 {
lab=vdd}
N -210 0 20 0 {
lab=vdd}
N 20 0 20 30 {
lab=vdd}
N -200 90 20 90 {
lab=vdd}
N 20 90 20 120 {
lab=vdd}
N -190 170 30 170 {
lab=vdd}
N 30 170 30 200 {
lab=vdd}
N -180 250 30 250 {
lab=vdd}
N 30 250 40 280 {
lab=vdd}
N -190 340 30 340 {
lab=vdd}
N 30 340 30 370 {
lab=vdd}
N -180 430 40 430 {
lab=vdd}
N 40 430 40 460 {
lab=vdd}
N -180 510 40 510 {
lab=vdd}
N 40 510 40 540 {
lab=vdd}
N 550 -90 770 -90 {
lab=vdd}
N 550 -90 550 -60 {
lab=vdd}
N 550 0 780 0 {
lab=vdd}
N 550 0 550 30 {
lab=vdd}
N 550 90 770 90 {
lab=vdd}
N 550 90 550 120 {
lab=vdd}
N 540 170 770 170 {
lab=vdd}
N 540 170 540 200 {
lab=vdd}
N 530 250 760 250 {
lab=vdd}
N 530 250 530 280 {
lab=vdd}
N 550 340 770 340 {
lab=vdd}
N 550 340 550 370 {
lab=vdd}
N 540 430 760 430 {
lab=vdd}
N 540 430 540 460 {
lab=vdd}
N 540 510 760 510 {
lab=vdd}
N 540 510 540 540 {
lab=vdd}
N 90 690 110 690 {
lab=clkb}
N 260 570 260 600 {
lab=#net3}
N 180 570 260 570 {
lab=#net3}
N 180 570 180 690 {
lab=#net3}
N 170 690 180 690 {
lab=#net3}
N 280 570 280 600 {
lab=#net4}
N 280 570 330 570 {
lab=#net4}
N 330 570 330 700 {
lab=#net4}
N 400 700 420 700 {
lab=clk}
N 330 700 340 700 {
lab=#net4}
N 180 -320 200 -320 {
lab=clkb}
N 260 -320 270 -320 {
lab=#net5}
N 270 -410 270 -320 {
lab=#net5}
N 270 -410 320 -410 {
lab=#net5}
N 320 -410 330 -410 {
lab=#net5}
N 330 -410 330 -400 {
lab=#net5}
N 370 -410 370 -400 {
lab=#net6}
N 370 -410 440 -410 {
lab=#net6}
N 440 -410 440 -330 {
lab=#net6}
N 1020 840 1040 840 {
lab=vdd}
N 1040 810 1040 840 {
lab=vdd}
N 1160 830 1190 830 {
lab=vdd}
N 1190 790 1190 830 {
lab=vdd}
N 1320 870 1340 870 {
lab=gnd}
N 1340 870 1340 910 {
lab=gnd}
N 1420 870 1470 870 {
lab=gnd}
N 1470 870 1470 900 {
lab=gnd}
N 520 -330 540 -330 {
lab=clk}
N 440 -330 460 -330 {
lab=#net6}
C {devices/lab_pin.sym} -310 -60 0 0 {name=p1 sig_type=std_logic lab=in1}
C {devices/lab_pin.sym} -310 -40 0 0 {name=p2 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 40 -60 2 0 {name=p3 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 50 -20 2 0 {name=p4 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -320 30 0 0 {name=p5 sig_type=std_logic lab=in2}
C {devices/lab_pin.sym} -320 50 0 0 {name=p6 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 30 30 2 0 {name=p7 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 40 70 2 0 {name=p8 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -310 120 0 0 {name=p9 sig_type=std_logic lab=in3}
C {devices/lab_pin.sym} -310 140 0 0 {name=p10 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 40 120 2 0 {name=p11 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 50 160 2 0 {name=p12 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -310 200 0 0 {name=p13 sig_type=std_logic lab=in4}
C {devices/lab_pin.sym} -310 220 0 0 {name=p14 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 40 200 2 0 {name=p15 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 50 240 2 0 {name=p16 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -300 280 0 0 {name=p17 sig_type=std_logic lab=in5}
C {devices/lab_pin.sym} -300 300 0 0 {name=p18 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 50 280 2 0 {name=p19 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 60 320 2 0 {name=p20 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -310 370 0 0 {name=p21 sig_type=std_logic lab=in6}
C {devices/lab_pin.sym} -310 390 0 0 {name=p22 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 40 370 2 0 {name=p23 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 50 410 2 0 {name=p24 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -300 460 0 0 {name=p25 sig_type=std_logic lab=in7}
C {devices/lab_pin.sym} -300 480 0 0 {name=p26 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 50 460 2 0 {name=p27 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 60 500 2 0 {name=p28 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} -300 540 0 0 {name=p29 sig_type=std_logic lab=in8}
C {devices/lab_pin.sym} -300 560 0 0 {name=p30 sig_type=std_logic lab=clk}
C {devices/lab_pin.sym} 50 540 2 0 {name=p31 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 60 580 2 0 {name=p32 sig_type=std_logic lab=gnd}
C {nmos_dnw.sym} 350 -250 3 1 {name=x9}
C {devices/lab_pin.sym} 890 -60 0 1 {name=p33 sig_type=std_logic lab=in1}
C {devices/lab_pin.sym} 890 -40 0 1 {name=p34 sig_type=std_logic lab=clkb}
C {devices/lab_pin.sym} 540 -60 2 1 {name=p35 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 530 -20 2 1 {name=p36 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} 900 30 0 1 {name=p37 sig_type=std_logic lab=in2}
C {devices/lab_pin.sym} 900 50 0 1 {name=p38 sig_type=std_logic lab=clkb}
C {devices/lab_pin.sym} 550 30 2 1 {name=p39 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 540 70 2 1 {name=p40 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} 890 120 0 1 {name=p41 sig_type=std_logic lab=in3}
C {devices/lab_pin.sym} 890 140 0 1 {name=p42 sig_type=std_logic lab=clkb}
C {devices/lab_pin.sym} 540 120 2 1 {name=p43 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 530 160 2 1 {name=p44 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} 890 200 0 1 {name=p45 sig_type=std_logic lab=in4}
C {devices/lab_pin.sym} 890 220 0 1 {name=p46 sig_type=std_logic lab=clkb}
C {devices/lab_pin.sym} 540 200 2 1 {name=p47 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 530 240 2 1 {name=p48 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} 880 280 0 1 {name=p49 sig_type=std_logic lab=in5}
C {devices/lab_pin.sym} 880 300 0 1 {name=p50 sig_type=std_logic lab=clkb}
C {devices/lab_pin.sym} 530 280 2 1 {name=p51 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 520 320 2 1 {name=p52 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} 890 370 0 1 {name=p53 sig_type=std_logic lab=in6}
C {devices/lab_pin.sym} 890 390 0 1 {name=p54 sig_type=std_logic lab=clkb}
C {devices/lab_pin.sym} 540 370 2 1 {name=p55 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 530 410 2 1 {name=p56 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} 880 460 0 1 {name=p57 sig_type=std_logic lab=in7}
C {devices/lab_pin.sym} 880 480 0 1 {name=p58 sig_type=std_logic lab=clkb}
C {devices/lab_pin.sym} 530 460 2 1 {name=p59 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 520 500 2 1 {name=p60 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} 880 540 0 1 {name=p61 sig_type=std_logic lab=in8}
C {devices/lab_pin.sym} 880 560 0 1 {name=p62 sig_type=std_logic lab=clkb}
C {devices/lab_pin.sym} 530 540 2 1 {name=p63 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 520 580 2 1 {name=p64 sig_type=std_logic lab=gnd}
C {pmos_cp1.sym} 270 750 3 1 {name=x18}
C {devices/lab_pin.sym} -170 860 1 0 {name=p69 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 0 940 2 0 {name=p70 sig_type=std_logic lab=clk
}
C {devices/lab_pin.sym} 0 960 2 0 {name=p71 sig_type=std_logic lab=clkb}
C {devices/lab_pin.sym} -170 1010 3 0 {name=p72 sig_type=std_logic lab=gnd}
C {clock_1.sym} -170 950 0 0 {name=x19}
C {devices/ipin.sym} -380 920 0 0 {name=p73 lab=clk_in}
C {devices/iopin.sym} -670 30 0 0 {name=p74 lab=gnd}
C {devices/iopin.sym} -670 0 0 0 {name=p75 lab=vdd}
C {devices/ipin.sym} 270 -450 0 0 {name=p76 lab=in}
C {devices/opin.sym} 240 960 1 0 {name=p77 lab=out}
C {capacitor_8.sym} -130 -40 0 0 {name=x1}
C {capacitor_8.sym} -150 50 0 0 {name=x2}
C {capacitor_8.sym} -140 140 0 0 {name=x3}
C {capacitor_8.sym} -130 220 0 0 {name=x4}
C {capacitor_8.sym} -120 300 0 0 {name=x5}
C {capacitor_8.sym} -130 390 0 0 {name=x6}
C {capacitor_8.sym} -120 480 0 0 {name=x7}
C {capacitor_8.sym} -120 560 0 0 {name=x8}
C {capacitor_8.sym} 710 -40 0 1 {name=x10}
C {capacitor_8.sym} 720 50 0 1 {name=x11}
C {capacitor_8.sym} 710 140 0 1 {name=x12}
C {capacitor_8.sym} 710 220 0 1 {name=x13}
C {capacitor_8.sym} 700 300 0 1 {name=x14}
C {capacitor_8.sym} 710 390 0 1 {name=x15}
C {capacitor_8.sym} 700 480 0 1 {name=x16}
C {capacitor_8.sym} 700 560 0 1 {name=x17}
C {devices/ipin.sym} -595 265 0 0 {name=p78 lab=in1}
C {devices/ipin.sym} -595 295 0 0 {name=p79 lab=in2}
C {devices/ipin.sym} -600 325 0 0 {name=p80 lab=in3}
C {devices/ipin.sym} -600 355 0 0 {name=p81 lab=in4}
C {devices/ipin.sym} -600 385 0 0 {name=p82 lab=in5}
C {devices/ipin.sym} -600 415 0 0 {name=p83 lab=in6}
C {devices/ipin.sym} -600 445 0 0 {name=p84 lab=in7}
C {devices/ipin.sym} -600 475 0 0 {name=p85 lab=in8}
C {sky130_fd_pr/cap_mim_m3_1.sym} 240 -70 0 0 {name=C3 model=cap_mim_m3_1 W=9 L=9 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 240 -120 1 0 {name=p98 sig_type=std_logic lab=clk}
C {sky130_fd_pr/cap_mim_m3_1.sym} 470 -70 0 1 {name=C1 model=cap_mim_m3_1 W=9 L=9 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 470 -120 1 0 {name=p99 sig_type=std_logic lab=clkb}
C {sky130_fd_pr/cap_mim_m3_1.sym} 140 690 1 0 {name=C2 model=cap_mim_m3_1 W=9 L=9 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 90 690 2 1 {name=p100 sig_type=std_logic lab=clkb
}
C {sky130_fd_pr/cap_mim_m3_1.sym} 370 700 3 1 {name=C4 model=cap_mim_m3_1 W=9 L=9 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 420 700 2 0 {name=p67 sig_type=std_logic lab=clk

}
C {sky130_fd_pr/cap_mim_m3_1.sym} 230 -320 1 1 {name=C5 model=cap_mim_m3_1 W=9 L=9 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 180 -320 2 1 {name=p65 sig_type=std_logic lab=clkb
}
C {sky130_fd_pr/cap_mim_m3_1.sym} 490 -330 3 0 {name=C6 model=cap_mim_m3_1 W=9 L=9 MF=1 spiceprefix=X}
C {sky130_fd_pr/nfet_01v8.sym} 1400 870 0 0 {name=M6
L=0.15
W=33.6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1140 830 0 0 {name=M8
L=0.15
W=33.6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/lab_pin.sym} 1020 810 1 0 {name=p88 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 1160 800 1 0 {name=p89 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 1020 870 3 0 {name=p90 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 1160 860 3 0 {name=p91 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 980 840 0 0 {name=p92 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} 1120 830 0 0 {name=p93 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} 1320 900 3 0 {name=p94 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} 1420 900 3 0 {name=p95 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} 1420 840 1 0 {name=p96 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} 1320 840 1 0 {name=p97 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} 1280 870 0 0 {name=p68 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 1380 870 0 0 {name=p86 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 1040 810 1 0 {name=p87 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 1190 790 1 0 {name=p101 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 1340 900 3 0 {name=p102 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} 1470 900 3 0 {name=p103 sig_type=std_logic lab=gnd}
C {devices/lab_pin.sym} 540 -330 2 0 {name=p104 sig_type=std_logic lab=clk}
C {sky130_fd_pr/pfet_01v8.sym} 1000 840 0 0 {name=M1
L=0.15
W=33.6
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8.sym} 1300 870 0 0 {name=M2
L=0.15
W=33.6
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
